* Generated by Xic from cell ERSFQ_NDRO
.tran 0.5p 1000p 0 0.25p UIC
B0 6 59 115 jjmit area=2.5
B1 8 61 116 jjmit area=2.5
B2 9 63 117 jjmit area=2.5
B3 11 65 118 jjmit area=2.5
B4 12 67 119 jjmit area=2.5
B5 14 69 120 jjmit area=2.5
B6 15 71 121 jjmit area=2.5
B7 17 73 122 jjmit area=2.5
B8 18 75 123 jjmit area=2.5
B9 20 77 124 jjmit area=2.5
B10 21 79 125 jjmit area=2.5
B11 23 81 126 jjmit area=2.5
B12 24 7 127 jjmit area=3.5
B13 25 10 128 jjmit area=3.5
B14 26 13 129 jjmit area=3.5
B15 27 16 130 jjmit area=3.5
B16 28 19 131 jjmit area=3.5
B17 29 22 132 jjmit area=3.5
B18 35 41 133 jjmit area=2.6
B19 36 42 134 jjmit area=1.8
B20 37 43 135 jjmit area=2.2
B21 38 44 136 jjmit area=1.08
B22 39 45 137 jjmit area=1
B23 40 46 138 jjmit area=0.7
B24 47 48 139 jjmit area=2.03
B25 43 97 140 jjmit area=2.18
B26 48 99 141 jjmit area=1.32
B27 50 51 142 jjmit area=2.25
B28 42 102 143 jjmit area=2.17
B29 51 104 144 jjmit area=2.8
B30 49 52 145 jjmit area=1
B31 53 54 146 jjmit area=1.75
B32 55 109 147 jjmit area=2.5
B33 56 111 148 jjmit area=1.76
B34 57 113 149 jjmit area=1.75
I0 0 89 pwl(0 0 5p 2738u)
L0 58 0 1p
L1 59 0 0.2p
L2 60 0 1p
L3 61 0 0.2p
L4 62 0 1p
L5 63 0 0.2p
L6 64 0 1p
L7 65 0 0.2p
L8 66 0 1p
L9 67 0 0.2p
L10 68 0 1p
L11 69 0 0.2p
L12 70 0 1p
L13 71 0 0.2p
L14 72 0 1p
L15 73 0 0.2p
L16 74 0 1p
L17 75 0 0.2p
L18 76 0 1p
L19 77 0 0.2p
L20 78 0 1p
L21 79 0 0.2p
L22 80 0 1p
L23 81 0 0.2p
L24 6 INBIAS 2p
L25 7 6 2p
L26 8 7 2p
L27 9 8 2p
L28 10 9 2p
L29 11 10 2p
L30 12 11 2p
L31 13 12 2p
L32 14 13 2p
L33 15 14 2p
L34 16 15 2p
L35 17 16 2p
L36 18 17 2p
L37 19 18 2p
L38 20 19 2p
L39 21 20 2p
L40 22 21 2p
L41 23 22 2p
L42 82 7 1p
L43 83 10 1p
L44 84 13 1p
L45 85 16 1p
L46 86 19 1p
L47 87 22 1p
L48 30 24 400p
L49 31 25 400p
L50 32 26 400p
L51 33 27 400p
L52 34 28 400p
L53 88 29 400p
L54 89 30 10p
L55 30 31 10p
L56 31 32 10p
L57 32 33 10p
L58 33 34 10p
L59 34 88 10p
L60 30 35 400p
L61 31 36 400p
L62 32 37 400p
L63 33 38 400p
L64 34 39 400p
L65 88 40 400p
L66 90 41 1p
L67 91 42 1p
L68 92 43 1p
L69 93 44 1p
L70 94 45 1p
L71 95 46 1p
L72 96 48 1p
L73 INSET 43 2.158p
L74 43 47 3.952p
L75 48 44 0.047p
L76 44 49 3.546p
L77 97 0 0.2p
L78 98 0 1p
L79 99 0 0.2p
L80 100 0 1p
L81 101 51 1p
L82 INRESET 42 2.623p
L83 42 50 2.964p
L84 51 49 2.938p
L85 102 0 0.2p
L86 103 0 1p
L87 104 0 0.2p
L88 105 0 1p
L89 106 52 1p
L90 52 45 0.468p
L91 45 107 0.445p
L92 108 54 1p
L93 INCLK 55 2.158p
L94 55 41 1.5p
L95 41 53 2p
L96 54 107 2.954p
L97 107 56 0.939p
L98 56 46 3.051p
L99 46 57 1.5p
L100 57 OUT 2.031p
L101 109 0 0.2p
L102 110 0 1p
L103 111 0 0.2p
L104 112 0 1p
L105 113 0 0.2p
L106 114 0 1p
R0 6 58 3.88
R1 8 60 3.88
R2 9 62 3.88
R3 11 64 3.88
R4 12 66 3.88
R5 14 68 3.88
R6 15 70 3.88
R7 17 72 3.88
R8 18 74 3.88
R9 20 76 3.88
R10 21 78 3.88
R11 23 80 3.88
R12 24 82 1.96
R13 25 83 1.96
R14 26 84 1.96
R15 27 85 1.96
R16 28 86 1.96
R17 29 87 1.96
R18 35 90 2.63
R19 36 91 3.81
R20 37 92 3.12
R21 38 93 6.35
R22 39 94 6.86
R23 40 95 9.8
R24 47 96 4.85
R25 43 98 4.45
R26 48 100 7.35
R27 50 101 4.31
R28 42 103 4.47
R29 51 105 3.46
R30 49 106 9.69
R31 53 108 5.54
R32 55 110 3.88
R33 56 112 5.54
R34 57 114 5.54
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0[c]
