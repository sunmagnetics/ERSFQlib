* Generated by Xic from cell TEST_ERSFQ_MERGE
.tran 0.5p 1000p 0 0.25p UIC
.plot tran v(36.x0)
I0 0 6 pulse(0 600u 1p 2p 2p 1p 10p)
I1 0 8 pwl(0 0 200p 0 203p 600u 206p 0)
I2 0 11 pwl(0 0 300p 0 303p 600u 306p 0)
R0 9 0 2
X0 2 3 1 4 ERSFQ_MERGE
X1 6 5 MITLL_DCSFQ
X2 5 1 MITLL_JTL
X3 8 7 MITLL_DCSFQ
X4 7 2 MITLL_JTL
X5 4 9 MITLL_JTL
X6 11 10 MITLL_DCSFQ
X7 10 3 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt ERSFQ_MERGE IN1 IN2 IBIAS OUT
B0 5 18 33 jjmit area=2.5
B1 7 20 34 jjmit area=2.5
B2 8 6 35 jjmit area=3.5
B3 9 12 36 jjmit area=5.5
B4 10 11 37 jjmit area=2
B5 10 26 38 jjmit area=2.5
B6 14 28 39 jjmit area=3.5
B7 15 16 40 jjmit area=2
B8 15 31 41 jjmit area=2.5
I0 0 23 pwl(0 0 5p 900u)
L0 17 0 0.2p
L1 18 0 1p
L2 19 0 0.2p
L3 20 0 1p
L4 IBIAS 5 2p
L5 5 6 2p
L6 6 7 2p
L7 21 6 0.2p
L8 22 8 400p
L9 23 22 10p
L10 22 9 400p
L11 25 11 1p
L12 24 12 1p
L13 IN1 10 2p
L14 11 13 0.7p
L15 26 0 0.2p
L16 27 0 1p
L17 13 12 0.25p
L18 12 14 2.9p
L19 14 OUT 2p
L20 30 16 1p
L21 28 0 0.2p
L22 29 0 1p
L23 IN2 15 2p
L24 16 13 0.7p
L25 31 0 0.2p
L26 32 0 1p
R0 5 17 3.88
R1 7 19 3.88
R2 8 21 2.77
R3 9 24 1.25
R4 10 25 4.85
R5 10 27 3.88
R6 14 29 3.23
R7 15 30 4.85
R8 15 32 3.88
.ends ERSFQ_MERGE
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X0[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X6[c]
.save @I1.X6[c]
.save @I0.X7[c]
.save @I0.X2[c]
.save @I0.X4[c]
.save @I0.X5[c]
.save @I1[c]
.save @I2[c]
.save @I0[c]
