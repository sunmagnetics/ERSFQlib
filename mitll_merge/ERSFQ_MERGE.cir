* Generated by Xic from cell ERSFQ_MERGE
.tran 0.5p 1000p 0 0.25p UIC
B0 5 18 33 jjmit area=2.5
B1 7 20 34 jjmit area=2.5
B2 8 6 35 jjmit area=3.5
B3 9 12 36 jjmit area=5.5
B4 10 11 37 jjmit area=2
B5 10 26 38 jjmit area=2.5
B6 14 28 39 jjmit area=3.5
B7 15 16 40 jjmit area=2
B8 15 31 41 jjmit area=2.5
I0 0 23 pwl(0 0 5p 900u)
L0 17 0 0.2p
L1 18 0 1p
L2 19 0 0.2p
L3 20 0 1p
L4 IBIAS 5 2p
L5 5 6 2p
L6 6 7 2p
L7 21 6 0.2p
L8 22 8 400p
L9 23 22 10p
L10 22 9 400p
L11 25 11 1p
L12 24 12 1p
L13 IN1 10 2p
L14 11 13 0.7p
L15 26 0 0.2p
L16 27 0 1p
L17 13 12 0.25p
L18 12 14 2.9p
L19 14 OUT 2p
L20 30 16 1p
L21 28 0 0.2p
L22 29 0 1p
L23 IN2 15 2p
L24 16 13 0.7p
L25 31 0 0.2p
L26 32 0 1p
R0 5 17 3.88
R1 7 19 3.88
R2 8 21 2.77
R3 9 24 1.25
R4 10 25 4.85
R5 10 27 3.88
R6 14 29 3.23
R7 15 30 4.85
R8 15 32 3.88
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0[c]
