* Generated by Xic from cell TEST_ERSFQ_SPLIT
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L10.x0#branch
I0 0 6 pulse(0 600u 1p 2p 2p 1p 10p)
I1 0 9 pwl(0 0 200p 0 203p 600u 206p 0 350p 0 353p 600u 356p 0)
R0 7 0 2
R1 10 0 2
X0 4 3 1 2 ERSFQ_SPLIT
X1 6 5 MITLL_DCSFQ
X2 5 3 MITLL_JTL
X3 1 7 MITLL_JTL
X4 9 8 MITLL_DCSFQ
X5 8 4 MITLL_JTL
X6 2 10 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt ERSFQ_SPLIT IIN IBIAS OUT1 OUT2
B0 5 16 29 jjmit area=2.5
B1 7 18 30 jjmit area=2.5
B2 8 6 31 jjmit area=3.5
B3 9 12 32 jjmit area=5.69
B4 11 23 33 jjmit area=2.5
B5 13 25 34 jjmit area=3.25
B6 14 27 35 jjmit area=2.5
I0 0 21 pwl(0 0 5p 919u)
L0 15 0 1p
L1 16 0 0.2p
L2 17 0 1p
L3 18 0 0.2p
L4 IBIAS 5 2p
L5 5 6 2p
L6 6 7 2p
L7 19 6 1p
L8 20 8 400p
L9 21 20 10p
L10 20 9 400p
L11 10 11 1.9p
L12 11 OUT1 2p
L13 22 12 1p
L14 23 0 0.2p
L15 24 0 1p
L16 IIN 13 1.4p
L17 13 12 2p
L18 12 10 0.4p
L19 25 0 0.2p
L20 26 0 1p
L21 10 14 1.9p
L22 14 OUT2 2p
L23 27 0 0.2p
L24 28 0 1p
R0 5 15 3.88
R1 7 17 3.88
R2 8 19 2.77
R3 9 22 1.7
R4 11 24 3.88
R5 13 26 2.98
R6 14 28 3.88
.ends ERSFQ_SPLIT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X0[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @I0.X3[c]
.save @I0.X6[c]
.save @I0.X2[c]
.save @I0.X5[c]
.save @I1[c]
.save @I0[c]
