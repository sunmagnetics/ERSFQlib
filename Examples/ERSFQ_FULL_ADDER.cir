* Generated by Xic from cell ERSFQ_FULL_ADDER
.tran 1p 6000p 2000p 0.5p UIC
.plot tran L2.x29#branch L2.x39#branch L4.x4#branch L2.x75#branch "v(80)/2O" "v(99)/2O"
I0 0 120 pwl(0 0 4340p 0 4343p 600u 4346p 0 5550p 0 5553p 600u 5556p 0)
I1 0 69 pwl(0 0 10p 30000u 600p 30000u 800p 27218u)
I2 0 127 pwl(0 0 3200p 0 3203p 600u 3206p 0)
I3 0 131 pwl(0 0 4200p 0 4203p 600u 4206p 0 4350p 0 4353p 600u 4356p 0)
I4 0 144 pulse(0 600u 1p 2p 2p 1p 50p)
L0 69 22 10p
L1 22 23 10p
L2 3 4 10p
L3 6 34 10p
L4 23 26 10p
L5 31 32 10p
L6 32 33 10p
L7 4 6 10p
L8 34 35 10p
L9 35 36 10p
L10 36 40 10p
L11 40 37 10p
L12 37 38 10p
L13 26 27 10p
L14 28 29 10p
L15 38 39 10p
L16 1 2 10p
L17 27 28 10p
L18 33 1 10p
L19 2 3 10p
L20 29 30 10p
L21 30 31 10p
L22 47 48 10p
L23 49 50 10p
L24 44 45 10p
L25 46 47 10p
L26 48 49 10p
L27 41 42 10p
L28 43 44 10p
L29 45 46 10p
L30 50 51 10p
L31 51 52 10p
L32 52 53 10p
L33 39 41 10p
L34 42 43 10p
L35 55 56 10p
L36 54 55 10p
L37 56 57 10p
L38 57 58 10p
L39 63 64 10p
L40 58 59 10p
L41 59 60 10p
L42 60 61 10p
L43 61 62 10p
L44 62 63 10p
L45 64 65 10p
L46 65 66 10p
L47 66 67 10p
L48 67 68 10p
L49 53 54 10p
R0 80 0 2
R1 99 0 2
X0 117 5 1 116 2 3 4 ERSFQ_DFF
X1 8 6 118 9 ERSFQ_SPLIT
X2 118 7 MITLL_JTL
X3 120 119 MITLL_DCSFQ
X4 119 117 MITLL_JTL
X5 116 8 MITLL_JTL
X6 9 10 MITLL_JTL
X7 11 22 23 12 feedingJTL2
X8 12 26 27 28 29 15 feedingJTL4
X9 15 30 31 32 33 16 feedingJTL4
X10 16 1 2 3 4 13 feedingJTL4
X11 14 34 35 36 145 37 38 17 feedingJTL6
X12 13 6 14 feedingJTL
X13 13 6 14 feedingJTL
X14 17 39 18 feedingJTL
X15 121 42 43 44 45 46 47 19 feedingJTL6
X16 19 48 49 50 51 52 53 20 feedingJTL6
X17 18 41 121 feedingJTL
X18 20 54 21 feedingJTL
X19 21 55 56 57 58 59 146 24 feedingJTL6
X20 24 61 62 63 64 25 feedingJTL4
X21 25 65 66 67 68 147 feedingJTL4
X22 78 71 70 122 34 35 36 40 148 38 ERSFQ_XOR
X23 73 7 75 123 55 56 57 58 59 60 ERSFQ_XOR
X24 79 74 65 124 66 67 68 ERSFQ_DFF
X25 72 73 MITLL_JTL
X26 76 22 125 81 ERSFQ_SPLIT
X27 125 71 MITLL_JTL
X28 77 39 72 82 ERSFQ_SPLIT
X29 127 126 MITLL_DCSFQ
X30 126 76 MITLL_JTL
X31 122 77 MITLL_JTL
X32 124 80 MITLL_JTL
X33 81 83 MITLL_JTL
X34 123 79 MITLL_JTL
X35 82 84 MITLL_JTL
X36 83 86 30 128 31 32 33 ERSFQ_DFF
X37 87 23 129 88 ERSFQ_SPLIT
X38 129 78 MITLL_JTL
X39 131 130 MITLL_DCSFQ
X40 130 87 MITLL_JTL
X41 10 84 92 132 48 49 85 51 52 53 54 ERSFQ_AND2
X42 128 89 MITLL_JTL
X43 88 90 MITLL_JTL
X44 132 91 MITLL_JTL
X45 90 94 26 133 93 28 29 ERSFQ_DFF
X46 133 95 MITLL_JTL
X47 97 91 96 134 61 62 63 64 ERSFQ_OR2
X48 89 95 98 135 42 43 41 44 45 46 47 ERSFQ_AND2
X49 135 97 MITLL_JTL
X50 134 99 MITLL_JTL
X51 100 94 86 MITLL_SPLIT
X52 101 5 11 MITLL_SPLIT
X53 102 101 MITLL_JTL
X54 103 100 MITLL_JTL
X55 104 70 MITLL_JTL
X56 105 98 MITLL_JTL
X57 106 92 MITLL_JTL
X58 107 75 MITLL_JTL
X59 108 96 MITLL_JTL
X60 109 74 MITLL_JTL
X61 136 102 103 MITLL_SPLIT
X62 137 104 105 MITLL_SPLIT
X63 138 106 107 MITLL_SPLIT
X64 139 108 109 MITLL_SPLIT
X65 110 136 MITLL_JTL
X66 111 137 MITLL_JTL
X67 112 138 MITLL_JTL
X68 113 139 MITLL_JTL
X69 140 110 111 MITLL_SPLIT
X70 141 112 113 MITLL_SPLIT
X71 114 140 MITLL_JTL
X72 115 141 MITLL_JTL
X73 142 114 115 MITLL_SPLIT
X74 143 142 MITLL_JTL
X75 144 143 MITLL_DCSFQ
.subckt feedingJTL4 CLK BIAS1 BIAS2 BIAS3 BIAS4 CONNECT
X0 CLK BIAS1 BIAS2 7 feedingJTL2
X1 7 BIAS3 BIAS4 CONNECT feedingJTL2
.ends feedingJTL4
.subckt feedingJTL6 CLK BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6 CONNECT
X0 CLK BIAS1 BIAS2 9 feedingJTL2
X1 9 BIAS3 BIAS4 10 feedingJTL2
X2 10 BIAS5 BIAS6 CONNECT feedingJTL2
.ends feedingJTL6
.subckt ERSFQ_OR2 IN1 IN2 INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4
.include ERSFQ_OR2_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=4.4, B1=1.1, B2=2, B3=1.2, B4=2.6, B5=2, B6=2, B7=2.5, B8=3.25, B9=3, B10=2, B11=2.5
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11
B0 9 13 49 jjmit area=B0
B1 10 14 50 jjmit area=B1
B2 11 15 51 jjmit area=B2
B3 12 16 52 jjmit area=B3
B4 17 33 53 jjmit area=B4
B5 18 19 54 jjmit area=B5
B6 20 21 55 jjmit area=B6
B7 20 37 56 jjmit area=B7
B8 23 24 57 jjmit area=B8
B9 24 40 58 jjmit area=B9
B10 25 42 59 jjmit area=B10
B11 26 44 60 jjmit area=B11
B12 27 28 61 jjmit area=B6
B13 27 47 62 jjmit area=B7
L0 BIAS1 9 400p
L1 BIAS2 10 400p
L2 BIAS3 11 400p
L3 BIAS4 12 400p
L4 29 13 1p
L5 30 14 1p
L6 31 15 1p
L7 32 16 1p
L8 INCLK 17 2.5p
L9 17 15 3.13p
L10 15 18 1.43p
L11 33 0 0.2p
L12 34 0 1p
L13 35 19 1p
L14 36 21 1p
L15 IN2 20 3p
L16 21 22 1.9p
L17 37 0 0.2p
L18 38 0 1p
L19 39 24 1p
L20 22 13 0.6p
L21 13 23 2.1p
L22 24 14 0.4p
L23 14 19 7.362p
L24 19 25 2.27p
L25 25 16 3.2p
L26 16 26 1.1p
L27 26 OUT 3.291p
L28 46 28 1p
L29 IN1 27 3p
L30 28 22 1.9p
L31 40 0 0.2p
L32 41 0 1p
L33 42 0 0.2p
L34 43 0 1p
L35 44 0 0.2p
L36 45 0 1p
L37 47 0 0.2p
L38 48 0 1p
R0 9 29 R0
R1 10 30 R1
R2 11 31 R2
R3 12 32 R3
R4 17 34 R4
R5 18 35 R5
R6 20 36 R6
R7 20 38 R7
R8 23 39 R8
R9 24 41 R9
R10 25 43 R10
R11 26 45 R11
R12 27 46 R6
R13 27 48 R7
.ends ERSFQ_OR2
.subckt feedingJTL2 CLK BIAS1 BIAS2 CONNECT
X0 CLK BIAS1 5 feedingJTL
X1 5 BIAS2 CONNECT feedingJTL
.ends feedingJTL2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt ERSFQ_XOR IN1 IN2 INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6
.param B0=2.25, B1=0.6, B4=1.8, B5=1.6, B6=1.69, B7=2.17, B8=1.69, B9=1.75, B10=2.5, B11=1.85, B13=1.63, B14=2.18
.include ERSFQ_XOR_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.25, B1=0.6, B4=1.8, B5=1.6, B7=2.17, B8=1.69, B9=1.75, B10=2.5, B11=1.85, B13=1.63, B14=2.18
.param R0=B0Rs/B0, R1=B0Rs/B1, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11, R13=B0Rs/B13, R14=B0Rs/B14
B0 11 17 58 jjmit area=B0
B1 12 18 59 jjmit area=B1
B2 13 19 60 jjmit area=B0
B3 14 20 61 jjmit area=B1
B4 15 21 62 jjmit area=B4
B5 16 22 63 jjmit area=B5
B6 21 23 64 jjmit area=B6
B7 21 41 65 jjmit area=B7
B8 24 25 66 jjmit area=B8
B9 27 44 67 jjmit area=B9
B10 24 46 68 jjmit area=B10
B11 26 28 69 jjmit area=B11
B12 29 30 70 jjmit area=B8
B13 31 50 71 jjmit area=B13
B14 32 52 72 jjmit area=B14
B15 33 54 73 jjmit area=B9
B16 29 56 74 jjmit area=B10
L0 BIAS1 11 400p
L1 BIAS2 12 400p
L2 BIAS3 13 400p
L3 BIAS4 14 400p
L4 BIAS5 15 400p
L5 BIAS6 16 400p
L6 34 17 1p
L7 35 18 1p
L8 36 19 1p
L9 37 20 1p
L10 38 21 1p
L11 39 22 1p
L12 40 23 1p
L13 INCLK 21 2.436p
L14 43 25 1p
L15 41 0 0.2p
L16 42 0 1p
L17 IN2 27 2.53p
L18 27 19 1p
L19 19 24 2.1p
L20 25 20 1.6p
L21 20 26 1.9p
L22 44 0 0.2p
L23 45 0 1p
L24 46 0 0.2p
L25 47 0 1p
L26 23 31 3.07p
L27 48 28 1p
L28 49 30 1p
L29 28 31 1.422p
L30 31 22 4.047p
L31 22 32 1.047p
L32 32 OUT 2.213p
L33 IN1 33 2.53p
L34 33 17 1p
L35 17 29 2.1p
L36 30 18 1.6p
L37 18 26 1.9p
L38 50 0 0.2p
L39 51 0 1p
L40 52 0 0.2p
L41 53 0 1p
L42 54 0 0.2p
L43 55 0 1p
L44 56 0 0.2p
L45 57 0 1p
R0 11 34 R0
R1 12 35 R1
R2 13 36 R0
R3 14 37 R1
R4 15 38 R4
R5 16 39 R5
R6 21 40 R6
R7 21 42 R7
R8 24 43 R8
R9 27 45 R9
R10 24 47 R10
R11 26 48 R11
R12 29 49 R8
R13 31 51 R13
R14 32 53 R14
R15 33 55 R9
R16 29 57 R10
.ends ERSFQ_XOR
.subckt ERSFQ_DFF IIN ICLK BIAS1 OUT BIAS2 BIAS3 BIAS4
.param R0=B0Rs/B0
.param R1=B0Rs/B1
.param R2=B0Rs/B2
.param R3=B0Rs/B3
.param R4=B0Rs/B4
.include ERSFQ_DFF_models.inc
.param R5=B0Rs/B5
.param Bc0=1
.param R6=B0Rs/B6
.param Ic0=0.0001
.param R7=B0Rs/B7
.param IcRs=100u*6.859904418
.param R8=B0Rs/B8
.param B0Rs=IcRs/Ic0*Bc0
.param R9=B0Rs/B9
.param B0=1.14, B1=2.5, B2=0.96, B3=2.6, B4=1.63, B5=1.5, B6=3, B7=2.5, B8=2, B9=2, B10=2.5
.param R10=B0Rs/B10
B0 8 9 38 jjmit area=B0
B1 9 23 39 jjmit area=B1
B2 10 13 40 jjmit area=B2
B3 11 15 41 jjmit area=B3
B4 12 16 42 jjmit area=B4
B5 14 20 43 jjmit area=B5
B6 17 18 44 jjmit area=B6
B7 19 30 45 jjmit area=B7
B8 18 32 46 jjmit area=B8
B9 20 34 47 jjmit area=B9
B10 21 36 48 jjmit area=B10
L0 BIAS3 8 400p
L1 22 9 0.2p
L2 BIAS2 10 400p
L3 BIAS1 11 400p
L4 ICLK 9 2p
L5 BIAS4 12 400p
L6 9 14 2.8p
L7 23 0 0.2p
L8 24 0 1p
L9 25 13 0.2p
L10 26 15 0.2p
L11 27 16 0.2p
L12 28 20 1p
L13 29 18 0.2p
L14 IIN 19 2p
L15 19 15 1p
L16 15 17 1.9p
L17 18 13 1.5p
L18 13 20 6p
L19 20 16 3p
L20 16 21 1p
L21 21 OUT 2p
L22 30 0 0.2p
L23 31 0 0.5p
L24 32 0 0.2p
L25 33 0 1p
L26 34 0 0.2p
L27 35 0 1p
L28 36 0 0.2p
L29 37 0 1p
R0 8 22 R0
R1 9 24 R1
R2 10 25 R2
R3 11 26 R3
R4 12 27 R4
R5 14 28 R5
R6 17 29 R6
R7 19 31 R7
R8 18 33 R8
R9 20 35 R9
R10 21 37 R10
.ends ERSFQ_DFF
.subckt ERSFQ_AND2 IN1 IN2 INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6 BIAS7
.include ERSFQ_AND2_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.3, B1=1.2, B2=2.2, B3=1.2, B4=2.3, B5=1.2, B6=0.7, B7=2.175, B8=1.755, B9=1.21, B10=1.05
.param B11=1.5, B12=1.5, B13=2.25, B14=2.175, B15=1.265, B16=1.38, B17=1.05, B18=1.5, B19=2.175, B20=1.755, B21=1.21
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10
.param R11=B0Rs/B11, R12=B0Rs/B12, R13=B0Rs/B13, R14=B0Rs/B14, R15=B0Rs/B15, R16=B0Rs/B16, R17=B0Rs/B17, R18=B0Rs/B18, R19=B0Rs/B19, R20=B0Rs/B20, R21=B0Rs/B21
B0 12 19 78 jjmit area=B0
B1 13 20 79 jjmit area=B1
B2 14 21 80 jjmit area=B2
B3 15 22 81 jjmit area=B3
B4 16 23 82 jjmit area=B4
B5 17 24 83 jjmit area=B5
B6 18 25 84 jjmit area=B6
B7 26 52 85 jjmit area=B7
B8 27 54 86 jjmit area=B8
B9 28 56 87 jjmit area=B9
B10 29 31 88 jjmit area=B10
B11 30 32 89 jjmit area=B11
B12 33 60 90 jjmit area=B12
B13 34 62 91 jjmit area=B13
B14 35 64 92 jjmit area=B14
B15 36 66 93 jjmit area=B15
B16 37 68 94 jjmit area=B16
B17 39 40 95 jjmit area=B17
B18 32 41 96 jjmit area=B18
B19 42 72 97 jjmit area=B19
B20 43 74 98 jjmit area=B20
B21 44 76 99 jjmit area=B21
L0 BIAS1 12 400p
L1 BIAS2 13 400p
L2 BIAS3 14 400p
L3 BIAS4 15 400p
L4 BIAS5 16 400p
L5 BIAS6 17 400p
L6 BIAS7 18 400p
L7 45 19 1p
L8 46 20 1p
L9 47 21 1p
L10 48 22 1p
L11 49 23 1p
L12 50 24 1p
L13 51 25 1p
L14 IN1 26 2p
L15 26 23 2.5375p
L16 23 27 2.5375p
L17 27 24 2.054p
L18 24 28 9.521p
L19 28 29 0.148p
L20 29 30 2.844p
L21 52 0 0.2p
L22 53 0 1p
L23 54 0 0.2p
L24 55 0 1p
L25 56 0 0.2p
L26 57 0 1p
L27 58 31 1p
L28 59 32 1p
L29 31 38 2.132p
L30 32 33 0.499p
L31 33 25 0.039p
L32 25 34 2.6p
L33 34 OUT 2.47p
L34 INCLK 35 2p
L35 35 21 2.511p
L36 21 36 2.511p
L37 36 22 0.239p
L38 22 37 1.924p
L39 37 38 0.01p
L40 38 39 2.171p
L41 60 0 0.2p
L42 61 0 1p
L43 62 0 0.2p
L44 63 0 1p
L45 64 0 0.2p
L46 65 0 1p
L47 66 0 0.2p
L48 67 0 1p
L49 68 0 0.2p
L50 69 0 1p
L51 70 40 1p
L52 71 41 1p
L53 40 41 2.904p
L54 IN2 42 2p
L55 42 19 2.4p
L56 19 43 2.4p
L57 43 20 2.057p
L58 20 44 9.521p
L59 44 40 0.179p
L60 72 0 0.2p
L61 73 0 1p
L62 74 0 0.2p
L63 75 0 1p
L64 76 0 0.2p
L65 77 0 1p
R0 12 45 R0
R1 13 46 R1
R2 14 47 R2
R3 15 48 R3
R4 16 49 R4
R5 17 50 R5
R6 18 51 R6
R7 26 53 R7
R8 27 55 R8
R9 28 57 R9
R10 29 58 R10
R11 30 59 R11
R12 33 61 R12
R13 34 63 R13
R14 35 65 R14
R15 36 67 R15
R16 37 69 R16
R17 39 70 R17
R18 32 71 R18
R19 42 73 R19
R20 43 75 R20
R21 44 77 R21
.ends ERSFQ_AND2
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_SPLIT IIN OUT1 OUT2
B0 5 9 16 jjmit area=2.5
B1 6 12 17 jjmit area=3.25
B2 7 14 18 jjmit area=2.5
I0 0 8 pwl(0 0 5p 569u)
L0 4 5 1.9p
L1 5 OUT1 2p
L2 8 11 0.2p
L3 9 0 0.2p
L4 10 0 1p
L5 IIN 6 1.4p
L6 6 11 2p
L7 11 4 0.4p
L8 12 0 0.2p
L9 13 0 1p
L10 4 7 1.9p
L11 7 OUT2 2p
L12 14 0 0.2p
L13 15 0 1p
R0 5 10 3.88
R1 6 13 2.98
R2 7 15 3.88
.ends MITLL_SPLIT
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt ERSFQ_SPLIT IIN BIAS1 OUT1 OUT2
.include ERSFQ_SPLIT_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=5.69, B1=2.5, B2=3.25, R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2
B0 5 8 18 jjmit area=B0
B1 7 12 19 jjmit area=B1
B2 9 14 20 jjmit area=B2
B3 10 16 21 jjmit area=B1
L0 BIAS1 5 400p
L1 6 7 1.9p
L2 7 OUT1 2p
L3 11 8 1p
L4 12 0 0.2p
L5 13 0 1p
L6 IIN 9 1.4p
L7 9 8 2p
L8 8 6 0.4p
L9 14 0 0.2p
L10 15 0 1p
L11 6 10 1.9p
L12 10 OUT2 2p
L13 16 0 0.2p
L14 17 0 1p
R0 5 11 R0
R1 7 13 R1
R2 9 15 R2
R3 10 17 R1
.ends ERSFQ_SPLIT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X51[c]
.save @I0.X52[c]
.save @I0.X62[c]
.save @I0.X69[c]
.save @I0.X70[c]
.save @I0.X64[c]
.save @I0.X61[c]
.save @I0.X63[c]
.save @I0.X73[c]
.save @I0.X38[c]
.save @I0.X35[c]
.save @I0.X67[c]
.save @I0.X4[c]
.save @I0.X65[c]
.save @I0.X71[c]
.save @I0.X49[c]
.save @I0.X44[c]
.save @I0.X43[c]
.save @I0.X58[c]
.save @I0.X55[c]
.save @I0.X53[c]
.save @I0.X2[c]
.save @I0.X5[c]
.save @I0.X66[c]
.save @I0.X40[c]
.save @I0.X25[c]
.save @I0.X33[c]
.save @I0.X6[c]
.save @I0.X31[c]
.save @I0.X32[c]
.save @I0.X34[c]
.save @I0.X60[c]
.save @I0.X68[c]
.save @I0.X56[c]
.save @I0.X54[c]
.save @I0.X50[c]
.save @I0.X46[c]
.save @I0.X30[c]
.save @I0.X72[c]
.save @I0.X42[c]
.save @I0.X27[c]
.save @I0.X57[c]
.save @I0.X59[c]
.save @I0.X74[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X29[c]
.save @I1.X29[c]
.save @I0.X39[c]
.save @I1.X39[c]
.save @I0.X75[c]
.save @I1.X75[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
.save @I3[c]
.save @I4[c]
