* Generated by Xic from cell TEST_ERSFQ_OR2

* Author: L. Schindler
* Version: 0.1
* Last modification date: 11 May 2018
* Last modification by: L. Schindler

* Copyright (c) 2018-2019 Lieze Schindler, Stellenbosch University

* Permission is hereby granted, free of charge, to any person obtaining a copy
* of this cell library and associated documentation files (the "Library"), to deal
* in the Library without restriction, including without limitation the rights
* to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
* copies of the Library, and to permit persons to whom the Library is
* furnished to do so, subject to the following conditions:

* The above copyright notice and this permission notice shall be included in all
* copies or substantial portions of the Library.

* THE LIBRARY IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
* IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
* FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
* AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
* LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
* OUT OF OR IN CONNECTION WITH THE LIBRARY OR THE USE OR OTHER DEALINGS IN THE
* LIBRARY.

*For questions about the library, contact Lieze Schindler, 17528283@sun.ac.za

.tran 0.5p 1000p 0 0.25p UIC
.plot tran L29.x6#branch L15.x6#branch L8.x6#branch L27.x6#branch
I0 0 13 pulse(0 600u 1p 2p 2p 1p 10p)
I1 0 14 pwl(0 0 5p 2270u 50p 2270u 100p 2050u)
I2 0 17 pulse(0 600u 30p 2p 2p 1p 50p)
I3 0 19 pwl(0 0 200p 0 203p 600u 206p 0 300p 0 303p 600u 306p 0 310p 0 313p
+ 600u 316p 0)
I4 0 22 pwl(0 0 308p 0 311p 600u 314p 0 400p 0 403p 600u 406p 0)
L0 14 1 10p
L1 1 2 10p
L2 2 3 10p
L3 3 4 10p
R0 20 0 2
X0 9 1 8 feedingJTL
X1 8 2 10 feedingJTL
X2 10 3 11 feedingJTL
X3 11 4 23 feedingJTL
X4 13 12 MITLL_DCSFQ
X5 12 9 MITLL_JTL
X6 7 6 5 15 1 2 3 4 ERSFQ_OR2
X7 17 16 MITLL_DCSFQ
X8 16 5 MITLL_JTL
X9 19 18 MITLL_DCSFQ
X10 18 6 MITLL_JTL
X11 15 20 MITLL_JTL
X12 22 21 MITLL_DCSFQ
X13 21 7 MITLL_JTL
.subckt ERSFQ_OR2 IN1 IN2 INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4
.include ERSFQ_OR2_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=4.4, B1=1.1, B2=2, B3=1.2, B4=2.6, B5=2, B6=2, B7=2.5, B8=3.25, B9=3, B10=2, B11=2.5
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11
B0 9 13 49 jjmit area=B0
B1 10 14 50 jjmit area=B1
B2 11 15 51 jjmit area=B2
B3 12 16 52 jjmit area=B3
B4 17 33 53 jjmit area=B4
B5 18 19 54 jjmit area=B5
B6 20 21 55 jjmit area=B6
B7 20 37 56 jjmit area=B7
B8 23 24 57 jjmit area=B8
B9 24 40 58 jjmit area=B9
B10 25 42 59 jjmit area=B10
B11 26 44 60 jjmit area=B11
B12 27 28 61 jjmit area=B6
B13 27 47 62 jjmit area=B7
L0 BIAS1 9 400p
L1 BIAS2 10 400p
L2 BIAS3 11 400p
L3 BIAS4 12 400p
L4 29 13 1p
L5 30 14 1p
L6 31 15 1p
L7 32 16 1p
L8 INCLK 17 2.5p
L9 17 15 3.13p
L10 15 18 1.43p
L11 33 0 0.2p
L12 34 0 1p
L13 35 19 1p
L14 36 21 1p
L15 IN2 20 3p
L16 21 22 1.9p
L17 37 0 0.2p
L18 38 0 1p
L19 39 24 1p
L20 22 13 0.6p
L21 13 23 2.1p
L22 24 14 0.4p
L23 14 19 7.362p
L24 19 25 2.27p
L25 25 16 3.2p
L26 16 26 1.1p
L27 26 OUT 3.291p
L28 46 28 1p
L29 IN1 27 3p
L30 28 22 1.9p
L31 40 0 0.2p
L32 41 0 1p
L33 42 0 0.2p
L34 43 0 1p
L35 44 0 0.2p
L36 45 0 1p
L37 47 0 0.2p
L38 48 0 1p
R0 9 29 R0
R1 10 30 R1
R2 11 31 R2
R3 12 32 R3
R4 17 34 R4
R5 18 35 R5
R6 20 36 R6
R7 20 38 R7
R8 23 39 R8
R9 24 41 R9
R10 25 43 R10
R11 26 45 R11
R12 27 46 R6
R13 27 48 R7
.ends ERSFQ_OR2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X5[c]
.save @I0.X8[c]
.save @I0.X10[c]
.save @I0.X11[c]
.save @I0.X13[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @I0.X7[c]
.save @I1.X7[c]
.save @I0.X9[c]
.save @I1.X9[c]
.save @I0.X12[c]
.save @I1.X12[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
.save @I3[c]
.save @I4[c]
