* Generated by Xic from cell ERSFQ_OR2
.tran 0.5p 1000p 0 0.25p UIC
B0 6 46 87 jjmit area=3.5
B1 8 48 88 jjmit area=3.5
B2 9 50 89 jjmit area=2.5
B3 11 52 90 jjmit area=2.5
B4 12 54 91 jjmit area=2.5
B5 14 56 92 jjmit area=2.5
B6 15 58 93 jjmit area=2.5
B7 17 60 94 jjmit area=2.5
B8 18 7 95 jjmit area=5
B9 19 10 96 jjmit area=3.5
B10 20 13 97 jjmit area=3.5
B11 21 16 98 jjmit area=3.5
B12 25 29 99 jjmit area=4.4
B13 26 30 100 jjmit area=1.1
B14 27 31 101 jjmit area=2
B15 28 32 102 jjmit area=1.2
B16 33 71 103 jjmit area=2.6
B17 34 35 104 jjmit area=2
B18 36 37 105 jjmit area=2
B19 36 75 106 jjmit area=2.5
B20 39 40 107 jjmit area=3.25
B21 40 78 108 jjmit area=3
B22 41 80 109 jjmit area=2
B23 42 82 110 jjmit area=2.5
B24 43 44 111 jjmit area=2
B25 43 85 112 jjmit area=2.5
I0 0 66 pwl(0 0 5p 2220u)
L0 45 0 1p
L1 46 0 0.2p
L2 47 0 1p
L3 48 0 0.2p
L4 49 0 1p
L5 50 0 0.2p
L6 51 0 1p
L7 52 0 0.2p
L8 53 0 1p
L9 54 0 0.2p
L10 55 0 1p
L11 56 0 0.2p
L12 57 0 1p
L13 58 0 0.2p
L14 59 0 1p
L15 60 0 0.2p
L16 6 IBIAS 2p
L17 7 6 2p
L18 8 7 2p
L19 9 8 2p
L20 10 9 2p
L21 11 10 2p
L22 12 11 2p
L23 13 12 2p
L24 14 13 2p
L25 15 14 2p
L26 16 15 2p
L27 17 16 2p
L28 61 7 1p
L29 62 10 1p
L30 63 13 1p
L31 64 16 1p
L32 22 18 400p
L33 23 19 400p
L34 24 20 400p
L35 65 21 400p
L36 66 22 1p
L37 22 23 1p
L38 23 24 1p
L39 24 65 1p
L40 22 25 400p
L41 23 26 400p
L42 24 27 400p
L43 65 28 400p
L44 67 29 1p
L45 68 30 1p
L46 69 31 1p
L47 70 32 1p
L48 INCLK 33 2.5p
L49 33 31 3.13p
L50 31 34 1.43p
L51 71 0 0.2p
L52 72 0 1p
L53 73 35 1p
L54 74 37 1p
L55 IN2 36 3p
L56 37 38 1.9p
L57 75 0 0.2p
L58 76 0 1p
L59 77 40 1p
L60 38 29 0.6p
L61 29 39 2.1p
L62 40 30 0.4p
L63 30 35 7.362p
L64 35 41 2.27p
L65 41 32 3.2p
L66 32 42 1.1p
L67 42 OUT 3.291p
L68 84 44 1p
L69 IN1 43 3p
L70 44 38 1.9p
L71 78 0 0.2p
L72 79 0 1p
L73 80 0 0.2p
L74 81 0 1p
L75 82 0 0.2p
L76 83 0 1p
L77 85 0 0.2p
L78 86 0 1p
R0 6 45 2.77
R1 8 47 2.77
R2 9 49 3.88
R3 11 51 3.88
R4 12 53 3.88
R5 14 55 3.88
R6 15 57 3.88
R7 17 59 3.88
R8 18 61 1.372
R9 19 62 1.96
R10 20 63 1.96
R11 21 64 1.96
R12 25 67 1.56
R13 26 68 6.24
R14 27 69 3.43
R15 28 70 5.72
R16 33 72 3.73
R17 34 73 4.85
R18 36 74 4.85
R19 36 76 3.88
R20 39 77 2.98
R21 40 79 3.23
R22 41 81 4.85
R23 42 83 3.88
R24 43 84 4.85
R25 43 86 3.88
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0[c]
