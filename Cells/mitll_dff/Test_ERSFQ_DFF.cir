* Generated by Xic from cell Test_ERSFQ_DFFT

* Author: L. Schindler
* Version: 0.1
* Last modification date: 11 May 2018
* Last modification by: L. Schindler

* Copyright (c) 2018-2019 Lieze Schindler, Stellenbosch University

* Permission is hereby granted, free of charge, to any person obtaining a copy
* of this cell library and associated documentation files (the "Library"), to deal
* in the Library without restriction, including without limitation the rights
* to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
* copies of the Library, and to permit persons to whom the Library is
* furnished to do so, subject to the following conditions:

* The above copyright notice and this permission notice shall be included in all
* copies or substantial portions of the Library.

* THE LIBRARY IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
* IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
* FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
* AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
* LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
* OUT OF OR IN CONNECTION WITH THE LIBRARY OR THE USE OR OTHER DEALINGS IN THE
* LIBRARY.

*For questions about the library, contact Lieze Schindler, 17528283@sun.ac.za

.tran 0.5p 100p 0 0.25p UIC
I0 0 6 pulse(0 600u 1p 2p 2p 1p 10p)
I1 0 8 pulse(0 600u 40p 2p 2p 1p 20p)
I2 0 11 pwl(0 0 450p 0 453p 600u 456p 0 600p 0 603p 600u 606p 0)
R0 9 0 2
X0 3 2 1 4 ERSFQ_DFFT
X1 6 5 MITLL_DCSFQ
X2 5 1 MITLL_JTL
X3 8 7 MITLL_DCSFQ
X4 7 2 MITLL_JTL
X5 4 9 MITLL_JTL
X6 11 10 MITLL_DCSFQ
X7 10 3 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt ERSFQ_DFFT IIN ICLK IBIAS OUT
B0 5 40 76 jjmit area=2.5
B1 7 42 77 jjmit area=2.5
B2 8 44 78 jjmit area=2.5
B3 10 46 79 jjmit area=2.5
B4 11 48 80 jjmit area=2.5
B5 13 50 81 jjmit area=2.5
B6 14 52 82 jjmit area=2.5
B7 16 54 83 jjmit area=2.5
B8 17 6 84 jjmit area=3.5
B9 18 9 85 jjmit area=3.5
B10 19 12 86 jjmit area=3.5
B11 20 15 87 jjmit area=3.5
B12 25 26 88 jjmit area=1.14
B13 26 61 89 jjmit area=2.5
B14 27 30 90 jjmit area=0.96
B15 28 32 91 jjmit area=2.6
B16 29 33 92 jjmit area=1.63
B17 31 37 93 jjmit area=1.5
B18 34 35 94 jjmit area=3
B19 36 68 95 jjmit area=2.5
B20 35 70 96 jjmit area=2
B21 37 72 97 jjmit area=2
B22 38 74 98 jjmit area=2.5
I0 0 59 pwl(0 0 5p 2033u)
L0 39 0 0.5p
L1 40 0 0.2p
L2 41 0 0.5p
L3 42 0 0.2p
L4 43 0 0.5p
L5 44 0 0.2p
L6 45 0 0.5p
L7 46 0 0.2p
L8 47 0 0.5p
L9 48 0 0.2p
L10 49 0 0.5p
L11 50 0 0.2p
L12 51 0 0.5p
L13 52 0 0.2p
L14 53 0 0.5p
L15 54 0 0.2p
L16 IBIAS 5 2p
L17 5 6 2p
L18 6 7 2p
L19 7 8 2p
L20 8 9 2p
L21 9 10 2p
L22 10 11 2p
L23 11 12 2p
L24 12 13 2p
L25 13 14 2p
L26 14 15 2p
L27 15 16 2p
L28 55 6 0.2p
L29 56 9 0.2p
L30 57 12 0.2p
L31 58 15 0.2p
L32 21 17 400p
L33 22 18 400p
L34 23 19 400p
L35 24 20 400p
L36 59 21 10p
L37 21 22 10p
L38 22 23 10p
L39 23 24 10p
L40 23 25 400p
L41 60 26 0.2p
L42 22 27 400p
L43 21 28 400p
L44 ICLK 26 2.2p
L45 24 29 400p
L46 26 31 2.8p
L47 61 0 0.2p
L48 62 0 1p
L49 63 30 0.2p
L50 64 32 0.2p
L51 65 33 0.2p
L52 66 37 1p
L53 67 35 0.2p
L54 IIN 36 2p
L55 36 32 1p
L56 32 34 1.9p
L57 35 30 1.5p
L58 30 37 6p
L59 37 33 3p
L60 33 38 1p
L61 38 OUT 2p
L62 68 0 0.2p
L63 69 0 0.5p
L64 70 0 0.2p
L65 71 0 1p
L66 72 0 0.2p
L67 73 0 1p
L68 74 0 0.2p
L69 75 0 1p
R0 5 39 3.88
R1 7 41 3.88
R2 8 43 3.88
R3 10 45 3.88
R4 11 47 3.88
R5 13 49 3.88
R6 14 51 3.88
R7 16 53 3.88
R8 17 55 2.77
R9 18 56 2.77
R10 19 57 2.77
R11 20 58 2.77
R12 25 60 6.02
R13 26 62 3.88
R14 27 63 7.15
R15 28 64 2.64
R16 29 65 4.2
R17 31 66 4.57
R18 34 67 3.43
R19 36 69 3.88
R20 35 71 8.67
R21 37 73 3.43
R22 38 75 3.88
.ends ERSFQ_DFFT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X6[c]
.save @I1.X6[c]
.save @I0.X0[c]
.save @I0.X2[c]
.save @I0.X4[c]
.save @I0.X5[c]
.save @I0.X7[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
