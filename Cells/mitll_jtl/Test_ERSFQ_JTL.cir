* Generated by Xic from cell Test_ERSFQ_JTL
.tran 0.5p 1000p 0 0.25p UIC
I0 0 4 pulse(0 600u 1p 2p 2p 1p 20p)
R0 8 0 2
T0 5 0 2 0 Z0=5 Td=10p
T1 7 0 13 0 Z0=5 Td=10p
T2 1 0 9 0 Z0=5 Td=10p
X0 10 2 1 ERSFQ_JTLT
X1 4 3 MITLL_DCSFQ
X2 3 5 MITLL_PTLTX
X3 11 6 MITLL_DCSFQ
X4 6 7 MITLL_PTLTX
X5 9 8 MITLL_PTLRX
.subckt MITLL_PTLRX IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends MITLL_PTLRX
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_PTLTX IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends MITLL_PTLTX
.subckt ERSFQ_JTL IN BIASCLK OUT
B0 4 31 59 jjmit area=2.5
B1 6 33 60 jjmit area=2.5
B2 7 35 61 jjmit area=2.5
B3 9 37 62 jjmit area=2.5
B4 10 39 63 jjmit area=2.5
B5 12 41 64 jjmit area=2.5
B6 13 5 65 jjmit area=3.5
B7 14 8 66 jjmit area=3.5
B8 15 11 67 jjmit area=3.5
B9 20 23 68 jjmit area=1.55
B10 21 24 69 jjmit area=3.5
B11 22 25 70 jjmit area=1.8
B12 26 49 71 jjmit area=1
B13 27 51 72 jjmit area=1
B14 28 53 73 jjmit area=2.5
B15 29 55 74 jjmit area=2.5
B16 25 57 75 jjmit area=2
L0 30 0 1p
L1 31 0 0.2p
L2 32 0 1p
L3 33 0 0.2p
L4 34 0 1p
L5 35 0 0.2p
L6 36 0 1p
L7 37 0 0.2p
L8 38 0 1p
L9 39 0 0.2p
L10 40 0 1p
L11 41 0 0.2p
L12 BIASCLK 4 2p
L13 4 5 2p
L14 5 6 2p
L15 6 7 2p
L16 7 8 2p
L17 8 9 2p
L18 9 10 2p
L19 10 11 2p
L20 11 12 2p
L21 42 5 0.2p
L22 43 8 0.2p
L23 44 11 0.2p
L24 13 16 400p
L25 14 17 400p
L26 15 18 400p
L27 19 16 20p
L28 16 17 20p
L29 17 18 20p
L30 16 20 400p
L31 17 21 400p
L32 18 22 400p
L33 46 23 0.2p
L34 47 24 0.2p
L35 48 25 0.2p
L36 IN 26 2p
L37 26 23 4.3p
L38 23 27 4.6p
L39 27 28 2p
L40 28 24 2p
L41 24 29 2p
L42 29 25 4.5p
L43 25 OUT 6p
L44 49 0 0.2p
L45 50 0 0.5p
L46 51 0 0.2p
L47 52 0 1p
L48 53 0 0.2p
L49 54 0 0.5p
L50 55 0 0.2p
L51 56 0 0.8p
L52 57 0 0.05p
L53 58 0 1p
R0 4 30 3.88
R1 6 32 3.88
R2 7 34 3.88
R3 9 36 3.88
R4 10 38 3.88
R5 12 40 3.88
R6 13 42 2.77
R7 14 43 2.77
R8 15 44 2.77
R9 45 19 1m
R10 20 46 4.43
R11 21 47 1.96
R12 22 48 3.81
R13 26 50 6.86
R14 27 52 6.86
R15 28 54 2.744
R16 29 56 2.744
R17 25 58 3.43
V0 45 0 pwl(0 0 5p 1.03391m)
.ends ERSFQ_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X5[c]
.save @I0.X2[c]
.save @I1.X2[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @I0[c]
.save @I1[c]
