* Generated by Xic from cell ERSFQ_JTL
.tran 0.5p 1000p 0 0.25p UIC
B0 4 14 24 jjmit area=2.5
B1 6 16 25 jjmit area=2.5
B2 7 5 26 jjmit area=3.5
B3 9 10 27 jjmit area=3.5
B4 11 20 28 jjmit area=2.5
B5 12 22 29 jjmit area=2.5
I0 0 18 pwl(0 0 5p 700u)
L0 13 0 1p
L1 14 0 0.2p
L2 15 0 1p
L3 16 0 0.2p
L4 BIASCLK 4 2p
L5 4 5 2p
L6 5 6 2p
L7 17 5 1p
L8 8 7 400p
L9 18 8 10p
L10 8 9 400p
L11 19 10 1p
L12 IN 11 2p
L13 11 10 2p
L14 10 12 2p
L15 12 OUT 4.5p
L16 20 0 0.2p
L17 21 0 1p
L18 22 0 0.2p
L19 23 0 1p
R0 4 13 3.88
R1 6 15 3.88
R2 7 17 2.77
R3 9 19 1.96
R4 11 21 2.744
R5 12 23 2.744
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0[c]
