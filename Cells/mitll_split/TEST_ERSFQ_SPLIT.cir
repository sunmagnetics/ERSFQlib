* Generated by Xic from cell TEST_ERSFQ_SPLIT
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L6.x4#branch L2.x4#branch L12.x4#branch
I0 0 6 pulse(0 600u 1p 2p 2p 1p 50p)
I1 0 8 pwl(0 0 5p 1019u 10p 1019u 20p 919u)
I2 0 11 pwl(0 0 200p 0 203p 600u 206p 0 350p 0 353p 600u 356p 0)
L0 8 1 10p
R0 7 0 2
R1 12 0 2
X0 4 1 13 feedingJTL
X1 6 5 MITLL_DCSFQ
X2 5 4 MITLL_JTL
X3 2 7 MITLL_JTL
X4 9 1 2 3 ERSFQ_SPLIT
X5 11 10 MITLL_DCSFQ
X6 10 9 MITLL_JTL
X7 3 12 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt ERSFQ_SPLIT IIN BIAS1 OUT1 OUT2
.include ERSFQ_SPLIT_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=5.69, B1=2.5, B2=3.25, R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2
B0 5 8 18 jjmit area=B0
B1 7 12 19 jjmit area=B1
B2 9 14 20 jjmit area=B2
B3 10 16 21 jjmit area=B1
L0 BIAS1 5 400p
L1 6 7 1.9p
L2 7 OUT1 2p
L3 11 8 1p
L4 12 0 0.2p
L5 13 0 1p
L6 IIN 9 1.4p
L7 9 8 2p
L8 8 6 0.4p
L9 14 0 0.2p
L10 15 0 1p
L11 6 10 1.9p
L12 10 OUT2 2p
L13 16 0 0.2p
L14 17 0 1p
R0 5 11 R0
R1 7 13 R1
R2 9 15 R2
R3 10 17 R1
.ends ERSFQ_SPLIT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X5[c]
.save @I1.X5[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X3[c]
.save @I0.X6[c]
.save @I0.X7[c]
.save @I0.X2[c]
.save @I2[c]
.save @I0[c]
.save @I1[c]
