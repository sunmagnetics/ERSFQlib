* Generated by Xic from cell ERSFQ_SPLIT
.tran 0.5p 1000p 0 0.25p UIC
B0 5 16 29 jjmit area=2.5
B1 7 18 30 jjmit area=2.5
B2 8 6 31 jjmit area=3.5
B3 9 12 32 jjmit area=5.69
B4 11 23 33 jjmit area=2.5
B5 13 25 34 jjmit area=3.25
B6 14 27 35 jjmit area=2.5
I0 0 21 pwl(0 0 5p 919u)
L0 15 0 1p
L1 16 0 0.2p
L2 17 0 1p
L3 18 0 0.2p
L4 IBIAS 5 2p
L5 5 6 2p
L6 6 7 2p
L7 19 6 1p
L8 20 8 400p
L9 21 20 10p
L10 20 9 400p
L11 10 11 1.9p
L12 11 OUT1 2p
L13 22 12 1p
L14 23 0 0.2p
L15 24 0 1p
L16 IIN 13 1.4p
L17 13 12 2p
L18 12 10 0.4p
L19 25 0 0.2p
L20 26 0 1p
L21 10 14 1.9p
L22 14 OUT2 2p
L23 27 0 0.2p
L24 28 0 1p
R0 5 15 3.88
R1 7 17 3.88
R2 8 19 2.77
R3 9 22 1.7
R4 11 24 3.88
R5 13 26 2.98
R6 14 28 3.88
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0[c]
