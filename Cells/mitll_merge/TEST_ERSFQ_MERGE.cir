* Generated by Xic from cell TEST_ERSFQ_MERGE
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L13.x3#branch L3.x3#branch L9.x3#branch "v(11)/2O"
I0 0 6 pulse(0 600u 1p 2p 2p 1p 50p)
I1 0 7 pwl(0 0 5p 1000u 10p 1000u 20p 900u)
I2 0 10 pwl(0 0 200p 0 203p 600u 206p 0)
I3 0 13 pwl(0 0 300p 0 303p 600u 306p 0)
L0 7 2 10p
R0 11 0 2
X0 1 2 14 feedingJTL
X1 6 5 MITLL_DCSFQ
X2 5 1 MITLL_JTL
X3 3 4 8 2 ERSFQ_MERGE
X4 10 9 MITLL_DCSFQ
X5 9 3 MITLL_JTL
X6 8 11 MITLL_JTL
X7 13 12 MITLL_DCSFQ
X8 12 4 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt ERSFQ_MERGE IN1 IN2 OUT BIAS1
.include ERSFQ_MERGE_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=5.5, B1=2, B2=2.5, B3=3.5
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3
B0 5 8 22 jjmit area=B0
B1 6 7 23 jjmit area=B1
B2 6 15 24 jjmit area=B2
B3 10 17 25 jjmit area=B3
B4 11 12 26 jjmit area=B1
B5 11 20 27 jjmit area=B2
L0 BIAS1 5 400p
L1 14 7 1p
L2 13 8 1p
L3 IN1 6 2p
L4 7 9 0.7p
L5 15 0 0.2p
L6 16 0 1p
L7 9 8 0.25p
L8 8 10 2.9p
L9 10 OUT 2p
L10 19 12 1p
L11 17 0 0.2p
L12 18 0 1p
L13 IN2 11 2p
L14 12 9 0.7p
L15 20 0 0.2p
L16 21 0 1p
R0 5 13 R0
R1 6 14 R1
R2 6 16 R2
R3 10 18 R3
R4 11 19 R1
R5 11 21 R2
.ends ERSFQ_MERGE
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @I0.X7[c]
.save @I1.X7[c]
.save @I0.X2[c]
.save @I0.X5[c]
.save @I0.X6[c]
.save @I0.X8[c]
.save @I0[c]
.save @I2[c]
.save @I3[c]
.save @I1[c]
