* Generated by Xic from cell TEST_ERSFQ_XOR
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L0.x6#branch L1.x6#branch L2.x6#branch L3.x6#branch L4.x6#branch L5.x6#branch
I0 0 15 pulse(0 600u 1p 2p 2p 1p 50p)
I1 0 16 pwl(0 0 5p 3110u 20p 3110u 30p 3010u)
I2 0 19 pwl(0 0 230p 0 233p 600u 236p 0 300p 0 303p 600u 306p 0)
I3 0 22 pwl(0 0 280p 0 283p 600u 286p 0 400p 0 403p 600u 406p 0)
L0 16 2 10p
L1 2 3 10p
L2 3 4 10p
L3 4 5 10p
L4 5 6 10p
L5 6 7 10p
R0 20 0 2
X0 1 2 3 4 5 6 7 23 feedingJTL6
X1 11 1 MITLL_JTL
X2 13 11 12 MITLL_SPLIT
X3 15 14 MITLL_DCSFQ
X4 14 13 MITLL_JTL
X5 12 8 MITLL_JTL
X6 10 9 8 17 2 3 4 5 6 7 ERSFQ_XOR
X7 19 18 MITLL_DCSFQ
X8 18 9 MITLL_JTL
X9 17 20 MITLL_JTL
X10 22 21 MITLL_DCSFQ
X11 21 10 MITLL_JTL
.subckt feedingJTL6 CLK BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6 CONNECT
X0 CLK BIAS1 BIAS2 9 feedingJTL2
X1 9 BIAS3 BIAS4 10 feedingJTL2
X2 10 BIAS5 BIAS6 CONNECT feedingJTL2
.ends feedingJTL6
.subckt feedingJTL2 CLK BIAS1 BIAS2 CONNECT
X0 CLK BIAS1 5 feedingJTL
X1 5 BIAS2 CONNECT feedingJTL
.ends feedingJTL2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt ERSFQ_XOR IN1 IN2 INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6
.param B0=2.25, B1=0.6, B4=1.8, B5=1.6, B6=1.69, B7=2.17, B8=1.69, B9=1.75, B10=2.5, B11=1.85, B13=1.63, B14=2.18
.include ERSFQ_XOR_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.25, B1=0.6, B4=1.8, B5=1.6, B7=2.17, B8=1.69, B9=1.75, B10=2.5, B11=1.85, B13=1.63, B14=2.18
.param R0=B0Rs/B0, R1=B0Rs/B1, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11, R13=B0Rs/B13, R14=B0Rs/B14
B0 11 17 58 jjmit area=B0
B1 12 18 59 jjmit area=B1
B2 13 19 60 jjmit area=B0
B3 14 20 61 jjmit area=B1
B4 15 21 62 jjmit area=B4
B5 16 22 63 jjmit area=B5
B6 21 23 64 jjmit area=B6
B7 21 41 65 jjmit area=B7
B8 24 25 66 jjmit area=B8
B9 27 44 67 jjmit area=B9
B10 24 46 68 jjmit area=B10
B11 26 28 69 jjmit area=B11
B12 29 30 70 jjmit area=B8
B13 31 50 71 jjmit area=B13
B14 32 52 72 jjmit area=B14
B15 33 54 73 jjmit area=B9
B16 29 56 74 jjmit area=B10
L0 BIAS1 11 400p
L1 BIAS2 12 400p
L2 BIAS3 13 400p
L3 BIAS4 14 400p
L4 BIAS5 15 400p
L5 BIAS6 16 400p
L6 34 17 1p
L7 35 18 1p
L8 36 19 1p
L9 37 20 1p
L10 38 21 1p
L11 39 22 1p
L12 40 23 1p
L13 INCLK 21 2.436p
L14 43 25 1p
L15 41 0 0.2p
L16 42 0 1p
L17 IN2 27 2.53p
L18 27 19 1p
L19 19 24 2.1p
L20 25 20 1.6p
L21 20 26 1.9p
L22 44 0 0.2p
L23 45 0 1p
L24 46 0 0.2p
L25 47 0 1p
L26 23 31 3.07p
L27 48 28 1p
L28 49 30 1p
L29 28 31 1.422p
L30 31 22 4.047p
L31 22 32 1.047p
L32 32 OUT 2.213p
L33 IN1 33 2.53p
L34 33 17 1p
L35 17 29 2.1p
L36 30 18 1.6p
L37 18 26 1.9p
L38 50 0 0.2p
L39 51 0 1p
L40 52 0 0.2p
L41 53 0 1p
L42 54 0 0.2p
L43 55 0 1p
L44 56 0 0.2p
L45 57 0 1p
R0 11 34 R0
R1 12 35 R1
R2 13 36 R0
R3 14 37 R1
R4 15 38 R4
R5 16 39 R5
R6 21 40 R6
R7 21 42 R7
R8 24 43 R8
R9 27 45 R9
R10 24 47 R10
R11 26 48 R11
R12 29 49 R8
R13 31 51 R13
R14 32 53 R14
R15 33 55 R9
R16 29 57 R10
.ends ERSFQ_XOR
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt MITLL_SPLIT IIN OUT1 OUT2
B0 5 9 16 jjmit area=2.5
B1 6 12 17 jjmit area=3.25
B2 7 14 18 jjmit area=2.5
I0 0 8 pwl(0 0 5p 569u)
L0 4 5 1.9p
L1 5 OUT1 2p
L2 8 11 0.2p
L3 9 0 0.2p
L4 10 0 1p
L5 IIN 6 1.4p
L6 6 11 2p
L7 11 4 0.4p
L8 12 0 0.2p
L9 13 0 1p
L10 4 7 1.9p
L11 7 OUT2 2p
L12 14 0 0.2p
L13 15 0 1p
R0 5 10 3.88
R1 6 13 2.98
R2 7 15 3.88
.ends MITLL_SPLIT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X7[c]
.save @I1.X7[c]
.save @I0.X10[c]
.save @I1.X10[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X9[c]
.save @I0.X11[c]
.save @I0.X1[c]
.save @I0.X8[c]
.save @I0.X5[c]
.save @I0.X4[c]
.save @I0.X2[c]
.save @I2[c]
.save @I3[c]
.save @I0[c]
.save @I1[c]
