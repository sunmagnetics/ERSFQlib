* Generated by Xic from cell ERSFQ_XOR

* Author: L. Schindler
* Version: 0.1
* Last modification date: 11 May 2018
* Last modification by: L. Schindler

* Copyright (c) 2018-2019 Lieze Schindler, Stellenbosch University

* Permission is hereby granted, free of charge, to any person obtaining a copy
* of this cell library and associated documentation files (the "Library"), to deal
* in the Library without restriction, including without limitation the rights
* to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
* copies of the Library, and to permit persons to whom the Library is
* furnished to do so, subject to the following conditions:

* The above copyright notice and this permission notice shall be included in all
* copies or substantial portions of the Library.

* THE LIBRARY IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
* IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
* FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
* AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
* LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
* OUT OF OR IN CONNECTION WITH THE LIBRARY OR THE USE OR OTHER DEALINGS IN THE
* LIBRARY.

*For questions about the library, contact Lieze Schindler, 17528283@sun.ac.za

.tran 0.5p 1000p 0 0.25p UIC
.param B0=2.25, B1=0.6, B4=1.8, B5=1.6, B6=1.69, B7=2.17, B8=1.69, B9=1.75, B10=2.5, B11=1.85, B13=1.63, B14=2.18
.include ERSFQ_XOR_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.25, B1=0.6, B4=1.8, B5=1.6, B7=2.17, B8=1.69, B9=1.75, B10=2.5, B11=1.85, B13=1.63, B14=2.18
.param R0=B0Rs/B0, R1=B0Rs/B1, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11, R13=B0Rs/B13, R14=B0Rs/B14
B0 11 17 58 jjmit area=B0
B1 12 18 59 jjmit area=B1
B2 13 19 60 jjmit area=B0
B3 14 20 61 jjmit area=B1
B4 15 21 62 jjmit area=B4
B5 16 22 63 jjmit area=B5
B6 21 23 64 jjmit area=B6
B7 21 41 65 jjmit area=B7
B8 24 25 66 jjmit area=B8
B9 27 44 67 jjmit area=B9
B10 24 46 68 jjmit area=B10
B11 26 28 69 jjmit area=B11
B12 29 30 70 jjmit area=B8
B13 31 50 71 jjmit area=B13
B14 32 52 72 jjmit area=B14
B15 33 54 73 jjmit area=B9
B16 29 56 74 jjmit area=B10
L0 BIAS1 11 400p
L1 BIAS2 12 400p
L2 BIAS3 13 400p
L3 BIAS4 14 400p
L4 BIAS5 15 400p
L5 BIAS6 16 400p
L6 34 17 1p
L7 35 18 1p
L8 36 19 1p
L9 37 20 1p
L10 38 21 1p
L11 39 22 1p
L12 40 23 1p
L13 INCLK 21 2.436p
L14 43 25 1p
L15 41 0 0.2p
L16 42 0 1p
L17 IN2 27 2.53p
L18 27 19 1p
L19 19 24 2.1p
L20 25 20 1.6p
L21 20 26 1.9p
L22 44 0 0.2p
L23 45 0 1p
L24 46 0 0.2p
L25 47 0 1p
L26 23 31 3.07p
L27 48 28 1p
L28 49 30 1p
L29 28 31 1.422p
L30 31 22 4.047p
L31 22 32 1.047p
L32 32 OUT 2.213p
L33 IN1 33 2.53p
L34 33 17 1p
L35 17 29 2.1p
L36 30 18 1.6p
L37 18 26 1.9p
L38 50 0 0.2p
L39 51 0 1p
L40 52 0 0.2p
L41 53 0 1p
L42 54 0 0.2p
L43 55 0 1p
L44 56 0 0.2p
L45 57 0 1p
R0 11 34 R0
R1 12 35 R1
R2 13 36 R0
R3 14 37 R1
R4 15 38 R4
R5 16 39 R5
R6 21 40 R6
R7 21 42 R7
R8 24 43 R8
R9 27 45 R9
R10 24 47 R10
R11 26 48 R11
R12 29 49 R8
R13 31 51 R13
R14 32 53 R14
R15 33 55 R9
R16 29 57 R10
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
