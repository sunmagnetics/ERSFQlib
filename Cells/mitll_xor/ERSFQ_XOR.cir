* Generated by Xic from cell ERSFQ_XOR
.tran 0.5p 1000p 0 0.25p UIC
B0 6 59 114 jjmit area=2.5
B1 8 61 115 jjmit area=2.5
B2 9 63 116 jjmit area=2.5
B3 11 65 117 jjmit area=2.5
B4 12 67 118 jjmit area=2.5
B5 14 69 119 jjmit area=2.5
B6 15 71 120 jjmit area=2.5
B7 17 73 121 jjmit area=2.5
B8 18 75 122 jjmit area=2.5
B9 20 77 123 jjmit area=2.5
B10 21 79 124 jjmit area=2.5
B11 23 81 125 jjmit area=2.5
B12 24 7 127 jjmit area=3.5
B13 25 10 128 jjmit area=3.5
B14 26 13 129 jjmit area=3.5
B15 27 16 130 jjmit area=3.5
B16 28 19 131 jjmit area=3.5
B17 29 22 132 jjmit area=3.5
B18 35 41 133 jjmit area=2.25
B19 36 42 134 jjmit area=0.6
B20 37 43 135 jjmit area=2.25
B21 38 44 136 jjmit area=0.6
B22 39 45 137 jjmit area=1.8
B23 40 46 138 jjmit area=1.6
B24 45 47 139 jjmit area=1.69
B25 45 97 140 jjmit area=2.17
B26 48 49 141 jjmit area=1.69
B27 51 100 142 jjmit area=1.75
B28 48 102 143 jjmit area=2.5
B29 50 52 144 jjmit area=1.85
B30 53 54 145 jjmit area=1.69
B31 55 106 146 jjmit area=1.63
B32 56 108 147 jjmit area=2.18
B33 57 110 148 jjmit area=1.75
B34 53 112 149 jjmit area=2.5
I0 0 89 pwl(0 0 5p 2910u)
L0 58 0 1p
L1 59 0 0.2p
L2 60 0 1p
L3 61 0 0.2p
L4 62 0 1p
L5 63 0 0.2p
L6 64 0 1p
L7 65 0 0.2p
L8 66 0 1p
L9 67 0 0.2p
L10 68 0 1p
L11 69 0 0.2p
L12 70 0 1p
L13 71 0 0.2p
L14 72 0 1p
L15 73 0 0.2p
L16 74 0 1p
L17 75 0 0.2p
L18 76 0 1p
L19 77 0 0.2p
L20 78 0 1p
L21 79 0 0.2p
L22 80 0 1p
L23 81 0 0.2p
L24 6 INBIAS 2p
L25 7 6 2p
L26 8 7 2p
L27 9 8 2p
L28 10 9 2p
L29 11 10 2p
L31 13 12 2p
L32 14 13 2p
L33 15 14 2p
L34 16 15 2p
L35 17 16 2p
L36 18 17 2p
L37 19 18 2p
L38 20 19 2p
L39 21 20 2p
L40 22 21 2p
L41 23 22 2p
L42 82 7 1p
L43 83 10 1p
L44 84 13 1p
L45 85 16 1p
L46 86 19 1p
L47 87 22 1p
L48 30 24 400p
L49 31 25 400p
L50 32 26 400p
L51 33 27 400p
L52 34 28 400p
L53 88 29 400p
L54 89 30 10p
L55 30 31 10p
L56 31 32 10p
L57 32 33 10p
L58 33 34 10p
L59 34 88 10p
L60 30 35 400p
L61 31 36 400p
L62 32 37 400p
L63 33 38 400p
L64 34 39 400p
L65 88 40 400p
L66 90 41 1p
L67 91 42 1p
L68 92 43 1p
L69 93 44 1p
L70 94 45 1p
L71 95 46 1p
L72 96 47 1p
L73 INCLK 45 2.436p
L74 99 49 1p
L75 97 0 0.2p
L76 98 0 1p
L77 IN2 51 2.53p
L78 51 43 1p
L79 43 48 2.1p
L80 49 44 1.6p
L81 44 50 1.9p
L82 100 0 0.2p
L83 101 0 1p
L84 102 0 0.2p
L85 103 0 1p
L86 47 55 3.07p
L87 104 52 1p
L88 105 54 1p
L89 52 55 1.422p
L90 55 46 4.047p
L91 46 56 1.047p
L92 56 OUT 2.213p
L93 IN1 57 2.53p
L94 57 41 1p
L95 41 53 2.1p
L96 54 42 1.6p
L97 42 50 1.9p
L98 106 0 0.2p
L99 107 0 1p
L100 108 0 0.2p
L101 109 0 1p
L102 110 0 0.2p
L103 111 0 1p
L104 112 0 0.2p
L105 113 0 1p
R0 6 58 3.88
R1 8 60 3.88
R2 9 62 3.88
R3 11 64 3.88
R4 12 66 3.88
R5 14 68 3.88
R6 15 70 3.88
R7 17 72 3.88
R8 18 74 3.88
R9 20 76 3.88
R10 21 78 3.88
R11 23 80 3.88
R12 24 82 1.96
R13 25 83 1.96
R14 26 84 1.96
R15 27 85 1.96
R16 28 86 1.96
R17 29 87 1.96
R18 35 90 3.05
R19 36 91 11.43
R20 37 92 3.05
R21 38 93 11.43
R22 39 94 3.81
R23 40 95 4.29
R24 45 96 5.4
R25 45 98 4.45
R26 48 99 5.4
R27 51 101 5.54
R28 48 103 3.88
R29 50 104 5.25
R30 53 105 5.4
R31 55 107 6
R32 56 109 4.45
R33 57 111 5.54
R34 53 113 3.88
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0[c]
