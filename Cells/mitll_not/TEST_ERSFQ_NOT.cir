* Generated by Xic from cell TEST_ERSFQ_NOT
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L34.x6#branch L20.x6#branch L12.x6#branch "v(15)/2O"
I0 0 11 pulse(0 600u 1p 2p 2p 1p 50p)
I1 0 12 pwl(0 0 5p 2175u 20p 2175u 30p 2075u)
I2 0 17 pwl(0 0 500p 0 503p 600u 506p 0 650p 0 653p 600u 656p 0)
L0 4 5 10p
L1 12 2 10p
L2 2 3 10p
L3 3 4 10p
R0 15 0 2
X0 1 2 3 4 5 18 feedingJTL4
X1 7 1 MITLL_JTL
X2 9 7 8 MITLL_SPLIT
X3 11 10 MITLL_DCSFQ
X4 10 9 MITLL_JTL
X5 8 6 MITLL_JTL
X6 14 6 13 2 3 4 5 ERSFQ_NOT
X7 13 15 MITLL_JTL
X8 17 16 MITLL_DCSFQ
X9 16 14 MITLL_JTL
.subckt feedingJTL4 CLK BIAS1 BIAS2 BIAS3 BIAS4 CONNECT
X0 CLK BIAS1 BIAS2 7 feedingJTL2
X1 7 BIAS3 BIAS4 CONNECT feedingJTL2
.ends feedingJTL4
.subckt feedingJTL2 CLK BIAS1 BIAS2 CONNECT
X0 CLK BIAS1 5 feedingJTL
X1 5 BIAS2 CONNECT feedingJTL
.ends feedingJTL2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt MITLL_SPLIT IIN OUT1 OUT2
B0 5 9 16 jjmit area=2.5
B1 6 12 17 jjmit area=3.25
B2 7 14 18 jjmit area=2.5
I0 0 8 pwl(0 0 5p 569u)
L0 4 5 1.9p
L1 5 OUT1 2p
L2 8 11 0.2p
L3 9 0 0.2p
L4 10 0 1p
L5 IIN 6 1.4p
L6 6 11 2p
L7 11 4 0.4p
L8 12 0 0.2p
L9 13 0 1p
L10 4 7 1.9p
L11 7 OUT2 2p
L12 14 0 0.2p
L13 15 0 1p
R0 5 10 3.88
R1 6 13 2.98
R2 7 15 3.88
.ends MITLL_SPLIT
.subckt ERSFQ_NOT IN CLK OUT BIAS1 BIAS2 BIAS3 BIAS4
.include ERSFQ_NOT_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.1, B1=2.3, B2=1.25, B3=1.1, B4=1.3, B5=1.159375, B6=1.5, B7=1.1, B8=2, B9=1.21, B10=1.05, B11=1.35, B12=2.16, B13=1.634883, B14=1.534914
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11, R12=B0Rs/B12, R13=B0Rs/B13, R14=B0Rs/B14
B0 8 12 54 jjmit area=B0
B1 9 13 55 jjmit area=B1
B2 10 14 56 jjmit area=B2
B3 11 15 57 jjmit area=B3
B4 18 35 58 jjmit area=B4
B5 19 37 59 jjmit area=B5
B6 16 17 60 jjmit area=B6
B7 24 20 61 jjmit area=B7
B8 21 40 62 jjmit area=B8
B9 22 42 63 jjmit area=B9
B10 23 44 64 jjmit area=B10
B11 24 25 65 jjmit area=B11
B12 27 48 66 jjmit area=B12
B13 28 50 67 jjmit area=B13
B14 29 52 68 jjmit area=B14
L0 BIAS1 8 400p
L1 BIAS2 9 400p
L2 BIAS3 10 400p
L3 BIAS4 11 400p
L4 30 12 1p
L5 31 13 1p
L6 32 14 1p
L7 33 15 1p
L8 34 17 1p
L9 17 18 0.239p
L10 18 15 5.53p
L11 15 19 1p
L12 19 OUT 1.846p
L13 17 20 0.734p
L14 35 0 0.27p
L15 36 0 1p
L16 37 0 0.12p
L17 38 0 1p
L18 39 20 1p
L19 23 16 3p
L20 CLK 21 1.53p
L21 21 13 1.01p
L22 13 22 3p
L23 22 23 3.6p
L24 23 14 8.3p
L25 14 24 0.4p
L26 40 0 0.328p
L27 41 0 1p
L28 42 0 0.234p
L29 43 0 1p
L30 44 0 0.567p
L31 45 0 1p
L32 46 25 1p
L33 25 26 1.186p
L34 IN 27 2.577p
L35 27 12 1p
L36 12 28 2.583p
L37 28 26 2.95p
L38 26 29 0.359p
L39 29 47 2.571p
L40 48 0 0.109p
L41 49 0 1p
L42 50 0 0.133p
L43 51 0 1p
L44 52 0 0.239p
L45 53 0 1p
R0 8 30 R0
R1 9 31 R1
R2 10 32 R2
R3 11 33 R3
R4 18 36 R4
R5 19 38 R5
R6 16 34 R6
R7 24 39 R7
R8 21 41 R8
R9 22 43 R9
R10 23 45 R10
R11 24 46 R11
R12 27 49 R12
R13 28 51 R13
R14 29 53 R14
R15 47 0 3.54
.ends ERSFQ_NOT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X8[c]
.save @I1.X8[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X7[c]
.save @I0.X5[c]
.save @I0.X9[c]
.save @I0.X4[c]
.save @I0.X1[c]
.save @I0.X2[c]
.save @I2[c]
.save @I0[c]
.save @I1[c]
