* Generated by Xic from cell TEST_ERSFQ_NOT
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L60.x0#branch L74.x0#branch "v(7)/2O"
I0 0 6 pulse(0 600u 1p 2p 2p 1p 10p)
I1 0 9 pulse(0 600u 30p 2p 2p 1p 50p)
I2 0 11 pwl(0 0 500p 0 503p 600u 506p 0 650p 0 653p 600u 656p 0)
R0 7 0 2
X0 4 3 2 1 ERSFQ_NOT
X1 6 5 MITLL_DCSFQ
X2 5 2 MITLL_JTL
X3 1 7 MITLL_JTL
X4 9 8 MITLL_DCSFQ
X5 8 3 MITLL_JTL
X6 11 10 MITLL_DCSFQ
X7 10 4 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt ERSFQ_NOT IN CLK IBIAS OUT
B0 5 47 92 jjmit area=2.5
B1 7 49 93 jjmit area=2.5
B2 8 51 94 jjmit area=2.5
B3 10 53 95 jjmit area=2.5
B4 11 55 96 jjmit area=2.5
B5 13 57 97 jjmit area=2.5
B6 14 59 98 jjmit area=2.5
B7 16 61 99 jjmit area=2.5
B8 17 6 100 jjmit area=3.5
B9 18 9 101 jjmit area=3.5
B10 19 12 102 jjmit area=3.5
B11 20 15 103 jjmit area=3.5
B12 24 28 104 jjmit area=2.1
B13 25 29 105 jjmit area=2.3
B14 26 30 106 jjmit area=1.25
B15 27 31 107 jjmit area=1.1
B16 34 73 108 jjmit area=1.3
B17 35 75 109 jjmit area=1.159375
B18 32 33 110 jjmit area=1.5
B19 40 36 111 jjmit area=1.1
B20 37 78 112 jjmit area=2
B21 38 80 113 jjmit area=1.21
B22 39 82 114 jjmit area=1.05
B23 40 41 115 jjmit area=1.35
B24 43 86 116 jjmit area=2.16
B25 44 88 117 jjmit area=1.634883
B26 45 90 118 jjmit area=1.534914
I0 0 67 pwl(0 0 5p 2000u)
L0 46 0 1p
L1 47 0 0.2p
L2 48 0 1p
L3 49 0 0.2p
L4 50 0 1p
L5 51 0 0.2p
L6 52 0 1p
L7 53 0 0.2p
L8 54 0 1p
L9 55 0 0.2p
L10 56 0 1p
L11 57 0 0.2p
L12 58 0 1p
L13 59 0 0.2p
L14 60 0 1p
L15 61 0 0.2p
L16 5 IBIAS 2p
L17 6 5 2p
L18 7 6 2p
L19 8 7 2p
L20 9 8 2p
L21 10 9 2p
L22 11 10 2p
L23 12 11 2p
L24 13 12 2p
L25 14 13 2p
L26 15 14 2p
L27 16 15 2p
L28 62 6 1p
L29 63 9 1p
L30 64 12 1p
L31 65 15 1p
L32 21 17 400p
L33 22 18 400p
L34 23 19 400p
L35 66 20 400p
L36 67 21 10p
L37 21 22 10p
L38 22 23 10p
L39 23 66 10p
L40 21 24 400p
L41 22 25 400p
L42 23 26 400p
L43 66 27 400p
L44 68 28 1p
L45 69 29 1p
L46 70 30 1p
L47 71 31 1p
L48 72 33 1p
L49 33 34 0.239p
L50 34 31 5.53p
L51 31 35 1p
L52 35 OUT 1.846p
L53 33 36 0.734p
L54 73 0 0.27p
L55 74 0 1p
L56 75 0 0.12p
L57 76 0 1p
L58 77 36 1p
L59 39 32 3p
L60 CLK 37 1.53p
L61 37 29 1.01p
L62 29 38 3p
L63 38 39 3.6p
L64 39 30 8.3p
L65 30 40 0.4p
L66 78 0 0.328p
L67 79 0 1p
L68 80 0 0.234p
L69 81 0 1p
L70 82 0 0.567p
L71 83 0 1p
L72 84 41 1p
L73 41 42 1.186p
L74 IN 43 2.577p
L75 43 28 1p
L76 28 44 2.583p
L77 44 42 2.95p
L78 42 45 0.359p
L79 45 85 2.571p
L80 86 0 0.109p
L81 87 0 1p
L82 88 0 0.133p
L83 89 0 1p
L84 90 0 0.239p
L85 91 0 1p
R0 5 46 3.88
R1 7 48 3.88
R2 8 50 3.88
R3 10 52 3.88
R4 11 54 3.88
R5 13 56 3.88
R6 14 58 3.88
R7 16 60 3.88
R8 17 62 2.77
R9 18 63 2.77
R10 19 64 2.77
R11 20 65 2.77
R12 24 68 3.27
R13 25 69 4.22
R14 26 70 7.76
R15 27 71 8.82
R16 32 72 4.57
R17 34 74 7.46
R18 35 76 5.92
R19 40 77 8.8
R20 37 79 4.85
R21 38 81 8
R22 39 83 9.2
R23 40 84 7.2
R24 85 0 3.54
R25 43 87 4.5
R26 44 89 4.2
R27 45 91 4.47
.ends ERSFQ_NOT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X0[c]
.save @I0.X3[c]
.save @I0.X7[c]
.save @I0.X5[c]
.save @I0.X2[c]
.save @I0.X6[c]
.save @I1.X6[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I2[c]
.save @I1[c]
.save @I0[c]
