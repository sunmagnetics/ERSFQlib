* Generated by Xic from cell TEST_ERSFQ_NDRO

* Author: L. Schindler
* Version: 0.1
* Last modification date: 11 May 2018
* Last modification by: L. Schindler

* Copyright (c) 2018-2019 Lieze Schindler, Stellenbosch University

* Permission is hereby granted, free of charge, to any person obtaining a copy
* of this cell library and associated documentation files (the "Library"), to deal
* in the Library without restriction, including without limitation the rights
* to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
* copies of the Library, and to permit persons to whom the Library is
* furnished to do so, subject to the following conditions:

* The above copyright notice and this permission notice shall be included in all
* copies or substantial portions of the Library.

* THE LIBRARY IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
* IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
* FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
* AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
* LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
* OUT OF OR IN CONNECTION WITH THE LIBRARY OR THE USE OR OTHER DEALINGS IN THE
* LIBRARY.

*For questions about the library, contact Lieze Schindler, 17528283@sun.ac.za

.tran 0.5p 1000p 0 0.25p UIC
.plot tran L13.x6#branch L22.x6#branch L33.x6#branch L40.x6#branch
I0 0 16 pwl(0 0 5p 3138u 20p 3138u 30p 3038u)
I1 0 14 pulse(0 600u 20p 2p 2p 1p 50p)
I2 0 19 pwl(0 0 520p 0 523p 600u 526p 0 560p 0 563p 600u 566p 0 710p 0 713p
+ 600u 716p 0 805p 0 808p 600u 811p 0)
I3 0 21 pwl(0 0 430p 0 433p 600u 436p 0 570p 0 573p 600u 576p 0 880p 0 883p
+ 600u 886p 0)
L0 16 2 10p
L1 2 3 10p
L2 3 4 10p
L3 5 6 10p
L4 6 7 10p
L5 4 5 10p
R0 22 0 2
X0 1 2 3 4 5 6 7 23 feedingJTL6
X1 11 1 MITLL_JTL
X2 13 11 12 MITLL_SPLIT
X3 14 15 MITLL_DCSFQ
X4 15 13 MITLL_JTL
X5 12 8 MITLL_JTL
X6 9 10 8 17 2 3 4 5 6 7 ERSFQ_NDRO
X7 19 18 MITLL_DCSFQ
X8 18 9 MITLL_JTL
X9 21 20 MITLL_DCSFQ
X10 20 10 MITLL_JTL
X11 17 22 MITLL_JTL
.subckt feedingJTL6 CLK BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6 CONNECT
X0 CLK BIAS1 BIAS2 9 feedingJTL2
X1 9 BIAS3 BIAS4 10 feedingJTL2
X2 10 BIAS5 BIAS6 CONNECT feedingJTL2
.ends feedingJTL6
.subckt feedingJTL2 CLK BIAS1 BIAS2 CONNECT
X0 CLK BIAS1 5 feedingJTL
X1 5 BIAS2 CONNECT feedingJTL
.ends feedingJTL2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt MITLL_SPLIT IIN OUT1 OUT2
B0 5 9 16 jjmit area=2.5
B1 6 12 17 jjmit area=3.25
B2 7 14 18 jjmit area=2.5
I0 0 8 pwl(0 0 5p 569u)
L0 4 5 1.9p
L1 5 OUT1 2p
L2 8 11 0.2p
L3 9 0 0.2p
L4 10 0 1p
L5 IIN 6 1.4p
L6 6 11 2p
L7 11 4 0.4p
L8 12 0 0.2p
L9 13 0 1p
L10 4 7 1.9p
L11 7 OUT2 2p
L12 14 0 0.2p
L13 15 0 1p
R0 5 10 3.88
R1 6 13 2.98
R2 7 15 3.88
.ends MITLL_SPLIT
.subckt ERSFQ_NDRO INSET INRESET INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6
.include ERSFQ_NDRO_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.6, B1=1.8, B2=2.2, B3=1.08, B4=1, B5=0.7, B6=2.03, B7=2.18, B8=1.32, B9=2.25, B10=2.17, B11=2.8, B12=1, B13=1.75, B14=2.5, B15=1.76, B16=1.75
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10, R11=B0Rs/B11, R12=B0Rs/B12, R13=B0Rs/B13, R14=B0Rs/B14, R15=B0Rs/B15, R16=B0Rs/B16
B0 11 17 59 jjmit area=B0
B1 12 18 60 jjmit area=B1
B2 13 19 61 jjmit area=B2
B3 14 20 62 jjmit area=B3
B4 15 21 63 jjmit area=B4
B5 16 22 64 jjmit area=B5
B6 23 24 65 jjmit area=B6
B7 19 41 66 jjmit area=B7
B8 24 43 67 jjmit area=B8
B9 26 27 68 jjmit area=B9
B10 18 46 69 jjmit area=B10
B11 27 48 70 jjmit area=B11
B12 25 28 71 jjmit area=B12
B13 29 30 72 jjmit area=B13
B14 31 53 73 jjmit area=B14
B15 32 55 74 jjmit area=B15
B16 33 57 75 jjmit area=B16
L0 BIAS1 11 400p
L1 BIAS2 12 400p
L2 BIAS3 13 400p
L3 BIAS4 14 400p
L4 BIAS5 15 400p
L5 BIAS6 16 400p
L6 34 17 1p
L7 35 18 1p
L8 36 19 1p
L9 37 20 1p
L10 38 21 1p
L11 39 22 1p
L12 40 24 1p
L13 INSET 19 2.158p
L14 19 23 3.952p
L15 24 20 0.047p
L16 20 25 3.546p
L17 41 0 0.2p
L18 42 0 1p
L19 43 0 0.2p
L20 44 0 1p
L21 45 27 1p
L22 INRESET 18 2.623p
L23 18 26 2.964p
L24 27 25 2.938p
L25 46 0 0.2p
L26 47 0 1p
L27 48 0 0.2p
L28 49 0 1p
L29 50 28 1p
L30 28 21 0.468p
L31 21 51 0.445p
L32 52 30 1p
L33 INCLK 31 2.158p
L34 31 17 1.5p
L35 17 29 2p
L36 30 51 2.954p
L37 51 32 0.939p
L38 32 22 3.051p
L39 22 33 1.5p
L40 33 OUT 2.031p
L41 53 0 0.2p
L42 54 0 1p
L43 55 0 0.2p
L44 56 0 1p
L45 57 0 0.2p
L46 58 0 1p
R0 11 34 R0
R1 12 35 R1
R2 13 36 R2
R3 14 37 R3
R4 15 38 R4
R5 16 39 R5
R6 23 40 R6
R7 19 42 R7
R8 24 44 R8
R9 26 45 R9
R10 18 47 R10
R11 27 49 R11
R12 25 50 R12
R13 29 52 R13
R14 31 54 R14
R15 32 56 R15
R16 33 58 R16
.ends ERSFQ_NDRO
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X7[c]
.save @I1.X7[c]
.save @I0.X9[c]
.save @I1.X9[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X8[c]
.save @I0.X4[c]
.save @I0.X1[c]
.save @I0.X5[c]
.save @I0.X10[c]
.save @I0.X11[c]
.save @I0.X2[c]
.save @I2[c]
.save @I3[c]
.save @I1[c]
.save @I0[c]
