* Generated by Xic from cell ERSFQ_AND2

* Author: L. Schindler
* Version: 0.1
* Last modification date: 11 May 2018
* Last modification by: L. Schindler

* Copyright (c) 2018-2019 Lieze Schindler, Stellenbosch University

* Permission is hereby granted, free of charge, to any person obtaining a copy
* of this cell library and associated documentation files (the "Library"), to deal
* in the Library without restriction, including without limitation the rights
* to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
* copies of the Library, and to permit persons to whom the Library is
* furnished to do so, subject to the following conditions:

* The above copyright notice and this permission notice shall be included in all
* copies or substantial portions of the Library.

* THE LIBRARY IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
* IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
* FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
* AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
* LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
* OUT OF OR IN CONNECTION WITH THE LIBRARY OR THE USE OR OTHER DEALINGS IN THE
* LIBRARY.

*For questions about the library, contact Lieze Schindler, 17528283@sun.ac.za

.tran 0.5p 1000p 0 0.25p UIC
.include ERSFQ_AND2_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.3, B1=1.2, B2=2.2, B3=1.2, B4=2.3, B5=1.2, B6=0.7, B7=2.175, B8=1.755, B9=1.21, B10=1.05
.param B11=1.5, B12=1.5, B13=2.25, B14=2.175, B15=1.265, B16=1.38, B17=1.05, B18=1.5, B19=2.175, B20=1.755, B21=1.21
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10
.param R11=B0Rs/B11, R12=B0Rs/B12, R13=B0Rs/B13, R14=B0Rs/B14, R15=B0Rs/B15, R16=B0Rs/B16, R17=B0Rs/B17, R18=B0Rs/B18, R19=B0Rs/B19, R20=B0Rs/B20, R21=B0Rs/B21
B0 12 19 78 jjmit area=B0
B1 13 20 79 jjmit area=B1
B2 14 21 80 jjmit area=B2
B3 15 22 81 jjmit area=B3
B4 16 23 82 jjmit area=B4
B5 17 24 83 jjmit area=B5
B6 18 25 84 jjmit area=B6
B7 26 52 85 jjmit area=B7
B8 27 54 86 jjmit area=B8
B9 28 56 87 jjmit area=B9
B10 29 31 88 jjmit area=B10
B11 30 32 89 jjmit area=B11
B12 33 60 90 jjmit area=B12
B13 34 62 91 jjmit area=B13
B14 35 64 92 jjmit area=B14
B15 36 66 93 jjmit area=B15
B16 37 68 94 jjmit area=B16
B17 39 40 95 jjmit area=B17
B18 32 41 96 jjmit area=B18
B19 42 72 97 jjmit area=B19
B20 43 74 98 jjmit area=B20
B21 44 76 99 jjmit area=B21
L0 BIAS1 12 400p
L1 BIAS2 13 400p
L2 BIAS3 14 400p
L3 BIAS4 15 400p
L4 BIAS5 16 400p
L5 BIAS6 17 400p
L6 BIAS7 18 400p
L7 45 19 1p
L8 46 20 1p
L9 47 21 1p
L10 48 22 1p
L11 49 23 1p
L12 50 24 1p
L13 51 25 1p
L14 IN1 26 2p
L15 26 23 2.5375p
L16 23 27 2.5375p
L17 27 24 2.054p
L18 24 28 9.521p
L19 28 29 0.148p
L20 29 30 2.844p
L21 52 0 0.2p
L22 53 0 1p
L23 54 0 0.2p
L24 55 0 1p
L25 56 0 0.2p
L26 57 0 1p
L27 58 31 1p
L28 59 32 1p
L29 31 38 2.132p
L30 32 33 0.499p
L31 33 25 0.039p
L32 25 34 2.6p
L33 34 OUT 2.47p
L34 INCLK 35 2p
L35 35 21 2.511p
L36 21 36 2.511p
L37 36 22 0.239p
L38 22 37 1.924p
L39 37 38 0.01p
L40 38 39 2.171p
L41 60 0 0.2p
L42 61 0 1p
L43 62 0 0.2p
L44 63 0 1p
L45 64 0 0.2p
L46 65 0 1p
L47 66 0 0.2p
L48 67 0 1p
L49 68 0 0.2p
L50 69 0 1p
L51 70 40 1p
L52 71 41 1p
L53 40 41 2.904p
L54 IN2 42 2p
L55 42 19 2.4p
L56 19 43 2.4p
L57 43 20 2.057p
L58 20 44 9.521p
L59 44 40 0.179p
L60 72 0 0.2p
L61 73 0 1p
L62 74 0 0.2p
L63 75 0 1p
L64 76 0 0.2p
L65 77 0 1p
R0 12 45 R0
R1 13 46 R1
R2 14 47 R2
R3 15 48 R3
R4 16 49 R4
R5 17 50 R5
R6 18 51 R6
R7 26 53 R7
R8 27 55 R8
R9 28 57 R9
R10 29 58 R10
R11 30 59 R11
R12 33 61 R12
R13 34 63 R13
R14 35 65 R14
R15 36 67 R15
R16 37 69 R16
R17 39 70 R17
R18 32 71 R18
R19 42 73 R19
R20 43 75 R20
R21 44 77 R21
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
