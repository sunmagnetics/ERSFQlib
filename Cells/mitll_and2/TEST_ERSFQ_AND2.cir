* Generated by Xic from cell TEST_ERSFQ_AND2
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L124.x0#branch L104.x0#branch L84.x0#branch "v(10)/2O" L103.x0#branch
I0 0 7 pulse(0 600u 1p 2p 2p 1p 20p)
I1 0 9 pwl(0 0 300p 0 303p 600u 306p 0 410p 0 413p 600u 416p 0)
I2 0 12 pulse(0 600u 180p 2p 2p 1p 50p)
I3 0 14 pwl(0 0 200p 0 203p 600u 206p 0 310p 0 313p 600u 316p 0)
R0 10 0 2
X0 1 3 2 5 4 ERSFQ_AND2
X1 7 6 MITLL_DCSFQ
X2 6 4 MITLL_JTL
X3 9 8 MITLL_DCSFQ
X4 8 1 MITLL_JTL
X5 5 10 MITLL_JTL
X6 12 11 MITLL_DCSFQ
X7 11 2 MITLL_JTL
X8 14 13 MITLL_DCSFQ
X9 13 3 MITLL_JTL
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt ERSFQ_AND2 IN1 IN2 INCLK OUT IBIAS
B0 6 74 143 jjmit area=2.5
B1 8 76 144 jjmit area=2.5
B2 9 78 145 jjmit area=2.5
B3 11 80 146 jjmit area=2.5
B4 12 82 147 jjmit area=2.5
B5 14 84 148 jjmit area=2.5
B6 15 86 149 jjmit area=2.5
B7 17 88 150 jjmit area=2.5
B8 18 90 151 jjmit area=2.5
B9 20 92 152 jjmit area=2.5
B10 22 94 153 jjmit area=2.5
B11 23 96 154 jjmit area=2.5
B12 24 98 155 jjmit area=2.5
B13 26 100 156 jjmit area=2.5
B14 27 7 157 jjmit area=3.5
B15 28 10 158 jjmit area=3.5
B16 29 13 159 jjmit area=3.5
B17 30 16 160 jjmit area=3.5
B18 31 19 161 jjmit area=3.5
B19 32 21 162 jjmit area=3.5
B20 33 25 163 jjmit area=3.5
B21 40 47 164 jjmit area=2.3
B22 41 48 165 jjmit area=1.2
B23 42 49 166 jjmit area=2.2
B24 43 50 167 jjmit area=1.2
B25 44 51 168 jjmit area=2.3
B26 45 52 169 jjmit area=1.2
B27 46 53 170 jjmit area=0.7
B28 54 117 171 jjmit area=2.175
B29 55 119 172 jjmit area=1.755
B30 56 121 173 jjmit area=1.21
B31 57 59 174 jjmit area=1.05
B32 58 60 175 jjmit area=1.5
B33 61 125 176 jjmit area=1.5
B34 62 127 177 jjmit area=2.25
B35 63 129 178 jjmit area=2.175
B36 64 131 179 jjmit area=1.265
B37 65 133 180 jjmit area=1.38
B38 67 68 181 jjmit area=1.05
B39 60 69 182 jjmit area=1.5
B40 70 137 183 jjmit area=2.175
B41 71 139 184 jjmit area=1.755
B42 72 141 185 jjmit area=1.21
I0 0 109 pwl(0 0 5p 3460u)
L0 73 0 1p
L1 74 0 0.2p
L2 75 0 1p
L3 76 0 0.2p
L4 77 0 1p
L5 78 0 0.2p
L6 79 0 1p
L7 80 0 0.2p
L8 81 0 1p
L9 82 0 0.2p
L10 83 0 1p
L11 84 0 0.2p
L12 85 0 1p
L13 86 0 0.2p
L14 87 0 1p
L15 88 0 0.2p
L16 89 0 1p
L17 90 0 0.2p
L18 91 0 1p
L19 92 0 0.2p
L20 93 0 1p
L21 94 0 0.2p
L22 95 0 1p
L23 96 0 0.2p
L24 97 0 1p
L25 98 0 0.2p
L26 99 0 1p
L27 100 0 0.2p
L28 6 IBIAS 2p
L29 7 6 2p
L30 8 7 2p
L31 9 8 2p
L32 10 9 2p
L33 11 10 2p
L34 12 11 2p
L35 13 12 2p
L36 14 13 2p
L37 15 14 2p
L38 16 15 2p
L39 17 16 2p
L40 18 17 2p
L41 19 18 2p
L42 20 19 2p
L43 22 20 2p
L44 21 22 2p
L45 23 21 2p
L46 24 23 2p
L47 25 24 2p
L48 26 25 2p
L49 101 7 1p
L50 102 10 1p
L51 103 13 1p
L52 104 16 1p
L53 105 19 1p
L54 106 21 1p
L55 107 25 1p
L56 34 27 400p
L57 35 28 400p
L58 36 29 400p
L59 37 30 400p
L60 38 31 400p
L61 39 32 400p
L62 108 33 400p
L63 109 34 20p
L64 34 35 20p
L65 35 36 20p
L66 36 37 20p
L67 37 38 20p
L68 38 39 20p
L69 39 108 20p
L70 34 40 400p
L71 35 41 400p
L72 36 42 400p
L73 37 43 400p
L74 38 44 400p
L75 39 45 400p
L76 108 46 400p
L77 110 47 1p
L78 111 48 1p
L79 112 49 1p
L80 113 50 1p
L81 114 51 1p
L82 115 52 1p
L83 116 53 1p
L84 IN1 54 2p
L85 54 51 2.5375p
L86 51 55 2.5375p
L87 55 52 2.054p
L88 52 56 9.521p
L89 56 57 0.148p
L90 57 58 2.844p
L91 117 0 0.2p
L92 118 0 1p
L93 119 0 0.2p
L94 120 0 1p
L95 121 0 0.2p
L96 122 0 1p
L97 123 59 1p
L98 124 60 1p
L99 59 66 2.132p
L100 60 61 0.499p
L101 61 53 0.039p
L102 53 62 2.6p
L103 62 OUT 2.47p
L104 INCLK 63 2p
L105 63 49 2.511p
L106 49 64 2.511p
L107 64 50 0.239p
L108 50 65 1.924p
L109 65 66 0.01p
L110 66 67 2.171p
L111 125 0 0.2p
L112 126 0 1p
L113 127 0 0.2p
L114 128 0 1p
L115 129 0 0.2p
L116 130 0 1p
L117 131 0 0.2p
L118 132 0 1p
L119 133 0 0.2p
L120 134 0 1p
L121 135 68 1p
L122 136 69 1p
L123 68 69 2.904p
L124 IN2 70 2p
L125 70 47 2.4p
L126 47 71 2.4p
L127 71 48 2.057p
L128 48 72 9.521p
L129 72 68 0.179p
L130 137 0 0.2p
L131 138 0 1p
L132 139 0 0.2p
L133 140 0 1p
L134 141 0 0.2p
L135 142 0 1p
R0 6 73 3.88
R1 8 75 3.88
R2 9 77 3.88
R3 11 79 3.88
R4 12 81 3.88
R5 14 83 3.88
R6 15 85 3.88
R7 17 87 3.88
R8 18 89 3.88
R9 20 91 3.88
R10 22 93 3.88
R11 23 95 3.88
R12 24 97 3.88
R13 26 99 3.88
R14 27 101 1.96
R15 28 102 1.96
R16 29 103 1.96
R17 30 104 1.96
R18 31 105 1.96
R19 32 106 1.96
R20 33 107 1.96
R21 40 110 4.22
R22 41 111 8.08
R23 42 112 4.41
R24 43 113 8.08
R25 44 114 4.22
R26 45 115 8.08
R27 46 116 13.86
R28 54 118 4.4
R29 55 120 5.5
R30 56 122 7.8
R31 57 123 9.6
R32 58 124 6.5
R33 61 126 6.5
R34 62 128 4.3
R35 63 130 4.4
R36 64 132 7.7
R37 65 134 6.7
R38 67 135 9.6
R39 60 136 6.5
R40 70 138 4.4
R41 71 140 5.5
R42 72 142 7.8
.ends ERSFQ_AND2
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X0[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X6[c]
.save @I1.X6[c]
.save @I0.X8[c]
.save @I1.X8[c]
.save @I0.X2[c]
.save @I0.X4[c]
.save @I0.X5[c]
.save @I0.X7[c]
.save @I0.X9[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
.save @I3[c]
