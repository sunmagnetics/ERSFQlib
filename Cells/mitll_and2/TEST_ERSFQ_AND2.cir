* Generated by Xic from cell TEST_ERSFQ_AND2
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L54.x2#branch L14.x2#branch L34.x2#branch L33.x2#branch "v(22)/2O"
I0 0 13 pwl(0 0 10p 3660u 20p 3660u 40p 3560u)
I1 0 16 pwl(0 0 300p 0 303p 600u 306p 0 410p 0 413p 600u 416p 0)
I2 0 21 pulse(0 600u 180p 2p 2p 1p 50p)
I3 0 24 pwl(0 0 200p 0 203p 600u 206p 0 310p 0 313p 600u 316p 0)
L0 4 5 10p
L1 5 6 10p
L2 6 7 10p
L3 7 8 10p
L4 13 2 10p
L5 2 3 10p
L6 3 4 10p
R0 22 0 2
X0 1 2 3 4 5 6 7 12 feedingJTL6
X1 12 8 25 feedingJTL
X2 9 11 10 14 2 3 4 5 6 7 8 ERSFQ_AND2
X3 16 15 MITLL_DCSFQ
X4 15 9 MITLL_JTL
X5 17 1 MITLL_JTL
X6 19 17 18 MITLL_SPLIT
X7 21 20 MITLL_DCSFQ
X8 20 19 MITLL_JTL
X9 14 22 MITLL_JTL
X10 18 10 MITLL_JTL
X11 24 23 MITLL_DCSFQ
X12 23 11 MITLL_JTL
.subckt feedingJTL6 CLK BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6 CONNECT
X0 CLK BIAS1 BIAS2 9 feedingJTL2
X1 9 BIAS3 BIAS4 10 feedingJTL2
X2 10 BIAS5 BIAS6 CONNECT feedingJTL2
.ends feedingJTL6
.subckt feedingJTL2 CLK BIAS1 BIAS2 CONNECT
X0 CLK BIAS1 5 feedingJTL
X1 5 BIAS2 CONNECT feedingJTL
.ends feedingJTL2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt ERSFQ_AND2 IN1 IN2 INCLK OUT BIAS1 BIAS2 BIAS3 BIAS4 BIAS5 BIAS6 BIAS7
.include ERSFQ_AND2_models.inc
.param Bc0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*Bc0
.param B0=2.3, B1=1.2, B2=2.2, B3=1.2, B4=2.3, B5=1.2, B6=0.7, B7=2.175, B8=1.755, B9=1.21, B10=1.05
.param B11=1.5, B12=1.5, B13=2.25, B14=2.175, B15=1.265, B16=1.38, B17=1.05, B18=1.5, B19=2.175, B20=1.755, B21=1.21
.param R0=B0Rs/B0, R1=B0Rs/B1, R2=B0Rs/B2, R3=B0Rs/B3, R4=B0Rs/B4, R5=B0Rs/B5, R6=B0Rs/B6, R7=B0Rs/B7, R8=B0Rs/B8, R9=B0Rs/B9, R10=B0Rs/B10
.param R11=B0Rs/B11, R12=B0Rs/B12, R13=B0Rs/B13, R14=B0Rs/B14, R15=B0Rs/B15, R16=B0Rs/B16, R17=B0Rs/B17, R18=B0Rs/B18, R19=B0Rs/B19, R20=B0Rs/B20, R21=B0Rs/B21
B0 12 19 78 jjmit area=B0
B1 13 20 79 jjmit area=B1
B2 14 21 80 jjmit area=B2
B3 15 22 81 jjmit area=B3
B4 16 23 82 jjmit area=B4
B5 17 24 83 jjmit area=B5
B6 18 25 84 jjmit area=B6
B7 26 52 85 jjmit area=B7
B8 27 54 86 jjmit area=B8
B9 28 56 87 jjmit area=B9
B10 29 31 88 jjmit area=B10
B11 30 32 89 jjmit area=B11
B12 33 60 90 jjmit area=B12
B13 34 62 91 jjmit area=B13
B14 35 64 92 jjmit area=B14
B15 36 66 93 jjmit area=B15
B16 37 68 94 jjmit area=B16
B17 39 40 95 jjmit area=B17
B18 32 41 96 jjmit area=B18
B19 42 72 97 jjmit area=B19
B20 43 74 98 jjmit area=B20
B21 44 76 99 jjmit area=B21
L0 BIAS1 12 400p
L1 BIAS2 13 400p
L2 BIAS3 14 400p
L3 BIAS4 15 400p
L4 BIAS5 16 400p
L5 BIAS6 17 400p
L6 BIAS7 18 400p
L7 45 19 1p
L8 46 20 1p
L9 47 21 1p
L10 48 22 1p
L11 49 23 1p
L12 50 24 1p
L13 51 25 1p
L14 IN1 26 2p
L15 26 23 2.5375p
L16 23 27 2.5375p
L17 27 24 2.054p
L18 24 28 9.521p
L19 28 29 0.148p
L20 29 30 2.844p
L21 52 0 0.2p
L22 53 0 1p
L23 54 0 0.2p
L24 55 0 1p
L25 56 0 0.2p
L26 57 0 1p
L27 58 31 1p
L28 59 32 1p
L29 31 38 2.132p
L30 32 33 0.499p
L31 33 25 0.039p
L32 25 34 2.6p
L33 34 OUT 2.47p
L34 INCLK 35 2p
L35 35 21 2.511p
L36 21 36 2.511p
L37 36 22 0.239p
L38 22 37 1.924p
L39 37 38 0.01p
L40 38 39 2.171p
L41 60 0 0.2p
L42 61 0 1p
L43 62 0 0.2p
L44 63 0 1p
L45 64 0 0.2p
L46 65 0 1p
L47 66 0 0.2p
L48 67 0 1p
L49 68 0 0.2p
L50 69 0 1p
L51 70 40 1p
L52 71 41 1p
L53 40 41 2.904p
L54 IN2 42 2p
L55 42 19 2.4p
L56 19 43 2.4p
L57 43 20 2.057p
L58 20 44 9.521p
L59 44 40 0.179p
L60 72 0 0.2p
L61 73 0 1p
L62 74 0 0.2p
L63 75 0 1p
L64 76 0 0.2p
L65 77 0 1p
R0 12 45 R0
R1 13 46 R1
R2 14 47 R2
R3 15 48 R3
R4 16 49 R4
R5 17 50 R5
R6 18 51 R6
R7 26 53 R7
R8 27 55 R8
R9 28 57 R9
R10 29 58 R10
R11 30 59 R11
R12 33 61 R12
R13 34 63 R13
R14 35 65 R14
R15 36 67 R15
R16 37 69 R16
R17 39 70 R17
R18 32 71 R18
R19 42 73 R19
R20 43 75 R20
R21 44 77 R21
.ends ERSFQ_AND2
.subckt feedingJTL CLK BIAS CONNECT
B0 4 8 12 jjmit area=2.5
B1 CONNECT 10 13 jjmit area=2.5
B2 6 5 14 jjmit area=3.5
L0 7 0 1p
L1 8 0 0.2p
L2 9 0 1p
L3 10 0 0.2p
L4 4 CLK 2p
L5 5 4 2p
L6 CONNECT 5 2p
L7 11 5 1p
L8 BIAS 6 400p
R0 4 7 3.88
R1 CONNECT 9 3.88
R2 6 11 1.96
.ends feedingJTL
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.subckt MITLL_SPLIT IIN OUT1 OUT2
B0 5 9 16 jjmit area=2.5
B1 6 12 17 jjmit area=3.25
B2 7 14 18 jjmit area=2.5
I0 0 8 pwl(0 0 5p 569u)
L0 4 5 1.9p
L1 5 OUT1 2p
L2 8 11 0.2p
L3 9 0 0.2p
L4 10 0 1p
L5 IIN 6 1.4p
L6 6 11 2p
L7 11 4 0.4p
L8 12 0 0.2p
L9 13 0 1p
L10 4 7 1.9p
L11 7 OUT2 2p
L12 14 0 0.2p
L13 15 0 1p
R0 5 10 3.88
R1 6 13 2.98
R2 7 15 3.88
.ends MITLL_SPLIT
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X7[c]
.save @I1.X7[c]
.save @I0.X11[c]
.save @I1.X11[c]
.save @I0.X9[c]
.save @I0.X10[c]
.save @I0.X12[c]
.save @I0.X4[c]
.save @I0.X5[c]
.save @I0.X8[c]
.save @I0.X6[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
.save @I3[c]
