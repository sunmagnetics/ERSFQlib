* Generated by Xic from cell TEST_ERSFQ_OR2
.tran 0.5p 1000p 0 0.25p UIC
.plot tran L69.x0#branch L55.x0#branch L48.x0#branch "v(12)/2O"
I0 0 7 pulse(0 600u 1p 2p 2p 1p 10p)
I1 0 9 pulse(0 600u 30p 2p 2p 1p 50p)
I2 0 11 pwl(0 0 200p 0 203p 600u 206p 0 300p 0 303p 600u 306p 0 310p 0 313p
+ 600u 316p 0)
I3 0 14 pwl(0 0 308p 0 311p 600u 314p 0 400p 0 403p 600u 406p 0)
R0 12 0 2
X0 3 2 1 5 4 ERSFQ_OR2
X1 7 6 MITLL_DCSFQ
X2 6 5 MITLL_JTL
X3 9 8 MITLL_DCSFQ
X4 8 1 MITLL_JTL
X5 11 10 MITLL_DCSFQ
X6 10 2 MITLL_JTL
X7 4 12 MITLL_JTL
X8 14 13 MITLL_DCSFQ
X9 13 3 MITLL_JTL
.subckt ERSFQ_OR2 IN1 IN2 INCLK IBIAS OUT
B0 6 46 87 jjmit area=3.5
B1 8 48 88 jjmit area=3.5
B2 9 50 89 jjmit area=2.5
B3 11 52 90 jjmit area=2.5
B4 12 54 91 jjmit area=2.5
B5 14 56 92 jjmit area=2.5
B6 15 58 93 jjmit area=2.5
B7 17 60 94 jjmit area=2.5
B8 18 7 95 jjmit area=5
B9 19 10 96 jjmit area=3.5
B10 20 13 97 jjmit area=3.5
B11 21 16 98 jjmit area=3.5
B12 25 29 99 jjmit area=4.4
B13 26 30 100 jjmit area=1.1
B14 27 31 101 jjmit area=2
B15 28 32 102 jjmit area=1.2
B16 33 71 103 jjmit area=2.6
B17 34 35 104 jjmit area=2
B18 36 37 105 jjmit area=2
B19 36 75 106 jjmit area=2.5
B20 39 40 107 jjmit area=3.25
B21 40 78 108 jjmit area=3
B22 41 80 109 jjmit area=2
B23 42 82 110 jjmit area=2.5
B24 43 44 111 jjmit area=2
B25 43 85 112 jjmit area=2.5
I0 0 66 pwl(0 0 5p 2220u)
L0 45 0 1p
L1 46 0 0.2p
L2 47 0 1p
L3 48 0 0.2p
L4 49 0 1p
L5 50 0 0.2p
L6 51 0 1p
L7 52 0 0.2p
L8 53 0 1p
L9 54 0 0.2p
L10 55 0 1p
L11 56 0 0.2p
L12 57 0 1p
L13 58 0 0.2p
L14 59 0 1p
L15 60 0 0.2p
L16 6 IBIAS 2p
L17 7 6 2p
L18 8 7 2p
L19 9 8 2p
L20 10 9 2p
L21 11 10 2p
L22 12 11 2p
L23 13 12 2p
L24 14 13 2p
L25 15 14 2p
L26 16 15 2p
L27 17 16 2p
L28 61 7 1p
L29 62 10 1p
L30 63 13 1p
L31 64 16 1p
L32 22 18 400p
L33 23 19 400p
L34 24 20 400p
L35 65 21 400p
L36 66 22 1p
L37 22 23 1p
L38 23 24 1p
L39 24 65 1p
L40 22 25 400p
L41 23 26 400p
L42 24 27 400p
L43 65 28 400p
L44 67 29 1p
L45 68 30 1p
L46 69 31 1p
L47 70 32 1p
L48 INCLK 33 2.5p
L49 33 31 3.13p
L50 31 34 1.43p
L51 71 0 0.2p
L52 72 0 1p
L53 73 35 1p
L54 74 37 1p
L55 IN2 36 3p
L56 37 38 1.9p
L57 75 0 0.2p
L58 76 0 1p
L59 77 40 1p
L60 38 29 0.6p
L61 29 39 2.1p
L62 40 30 0.4p
L63 30 35 7.362p
L64 35 41 2.27p
L65 41 32 3.2p
L66 32 42 1.1p
L67 42 OUT 3.291p
L68 84 44 1p
L69 IN1 43 3p
L70 44 38 1.9p
L71 78 0 0.2p
L72 79 0 1p
L73 80 0 0.2p
L74 81 0 1p
L75 82 0 0.2p
L76 83 0 1p
L77 85 0 0.2p
L78 86 0 1p
R0 6 45 2.77
R1 8 47 2.77
R2 9 49 3.88
R3 11 51 3.88
R4 12 53 3.88
R5 14 55 3.88
R6 15 57 3.88
R7 17 59 3.88
R8 18 61 1.372
R9 19 62 1.96
R10 20 63 1.96
R11 21 64 1.96
R12 25 67 1.56
R13 26 68 6.24
R14 27 69 3.43
R15 28 70 5.72
R16 33 72 3.73
R17 34 73 4.85
R18 36 74 4.85
R19 36 76 3.88
R20 39 77 2.98
R21 40 79 3.23
R22 41 81 4.85
R23 42 83 3.88
R24 43 84 4.85
R25 43 86 3.88
.ends ERSFQ_OR2
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X9[c]
.save @I0.X6[c]
.save @I0.X4[c]
.save @I0.X7[c]
.save @I0.X2[c]
.save @I0.X5[c]
.save @I1.X5[c]
.save @I0.X8[c]
.save @I1.X8[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X0[c]
.save @I1[c]
.save @I2[c]
.save @I3[c]
.save @I0[c]
